*
* Copyright 2019 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
** Generated by bif2cdl v3.2 **
** Version: 2003Q2V2
** Name: RF-2P-HS Register File Generator|TSMC CL018G Process
** Comment:
** Configuration:  -instname "rf2p_512x64_4_50" -words 512 -bits 64 \
** Configuration: -frequency 50 -ring_width 10 -mux 4 -drive 3 -writ\
** Configuration: e_mask off -wp_size 8 -top_layer met6 -power_type \
** Configuration: rings -horiz met3 -vert met2 -cust_comment "" -lef\
** Configuration: t_bus_delim "[" -right_bus_delim "]" -pwr_gnd_rena\
** Configuration: me "VDD:VDD,GND:VSS" -prefix "" -pin_space 0.0 -na\
** Configuration: me_case upper -check_instname on -diodes on -insid\
** Configuration: e_ring_type GND
** Codefile:
*
** begin lvs.header
** $Revision: 1.2 $
*.SCALE meter
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT rf2p_512x64_4_50WR D DWA DWA_ GTP WEI_ VSS VDD
** rf2p_512x64_4_50WR: 41 flat devices **
d33 VSS D DN 0.3364P 2.32U
m1 DWA DWIN VDD VDD P L=0.18U W=1.56U
m10 N48 DWIN VDD VDD P L=0.18U W=0.42U
m11 DWPD N16 N47 VSS N L=0.18U W=0.42U
m12 N47 DWIN VSS VSS N L=0.18U W=0.42U
m13 DWPDB GTPND N50 VDD P L=0.18U W=0.42U
m14 N50 DWINB VDD VDD P L=0.18U W=0.42U
m15 DWPDB N16 N49 VSS N L=0.18U W=0.42U
m16 N49 DWINB VSS VSS N L=0.18U W=0.42U
m17 DWI DI VDD VDD P L=0.18U W=0.85U
m18 N51 DI VSS VSS N L=0.18U W=0.85U
m19 DWI N29 VDD VDD P L=0.18U W=0.85U
m2 DWA DWIN VSS VSS N L=0.18U W=2.92U
m20 DWI N29 N51 VSS N L=0.18U W=0.85U
m21 DWIB DI_ VDD VDD P L=0.18U W=0.85U
m22 N52 DI_ VSS VSS N L=0.18U W=0.85U
m23 DWIB N29 VDD VDD P L=0.18U W=0.85U
m24 DWIB N29 N52 VSS N L=0.18U W=0.85U
m25 DWPD N16 DWI VDD P L=0.18U W=0.85U
m26 DWPDB N16 DWIB VDD P L=0.18U W=0.85U
m27 DWPD GTPND DWI VSS N L=0.18U W=0.85U
m28 DWPDB GTPND DWIB VSS N L=0.18U W=0.85U
m29 GTPND GTP VDD VDD P L=0.18U W=0.65U
m3 DWA_ DWINB VDD VDD P L=0.18U W=1.56U
m30 GTPND GTP VSS VSS N L=0.18U W=0.3U
m31 N29 WEI_ VDD VDD P L=0.18U W=0.47U
m32 N29 WEI_ VSS VSS N L=0.18U W=0.22U
m34 DI_ DI VDD VDD P L=0.18U W=0.47U
m35 DI_ DI VSS VSS N L=0.18U W=0.22U
m36 DI N40 VDD VDD P L=0.18U W=0.47U
m37 DI N40 VSS VSS N L=0.18U W=0.22U
m38 N40 D VDD VDD P L=0.18U W=0.47U
m39 N40 D VSS VSS N L=0.18U W=0.22U
m4 DWA_ DWINB VSS VSS N L=0.18U W=2.92U
m40 N16 GTPND VDD VDD P L=0.18U W=0.76U
m41 N16 GTPND VSS VSS N L=0.18U W=0.36U
m5 DWIN DWPD VDD VDD P L=0.18U W=1.36U
m6 DWIN DWPD VSS VSS N L=0.18U W=0.64U
m7 DWINB DWPDB VDD VDD P L=0.18U W=1.36U
m8 DWINB DWPDB VSS VSS N L=0.18U W=0.64U
m9 DWPD GTPND N48 VDD P L=0.18U W=0.42U
.ENDS rf2p_512x64_4_50WR
****
.SUBCKT rf2p_512x64_4_50CDWL BLA BLA_ BLB BLB_ DW DWWR DW_ GTP YP YP0 YP1 YP2
+  YP3 VSS VDD
** rf2p_512x64_4_50CDWL: 14 flat devices **
m1 BLB YI VDD VDD P L=0.18U W=1.56U
m10 GTPIN N18 GTP VDD P L=0.18U W=0.64U
m11 GTP YP GTPIN VSS N L=0.18U W=0.3U
m12 N18 YP VDD VDD P L=0.18U W=0.47U
m13 N18 YP VSS VSS N L=0.18U W=0.22U
m14 VSS N18 GTPIN VSS N L=0.18U W=0.22U
m2 BLB_ YI VDD VDD P L=0.18U W=1.56U
m3 YI YIIN VDD VDD P L=0.18U W=3.2U
m4 YI YIIN VSS VSS N L=0.18U W=1.5U
m5 YIIN GTPIN VDD VDD P L=0.18U W=1.43U
m6 YIIN GTPIN VSS VSS N L=0.18U W=0.67U
m7 BLB YI BLB_ VDD P L=0.18U W=1.56U
m8 DW YI BLB VSS N L=0.18U W=2.92U
m9 DW_ YI BLB_ VSS N L=0.18U W=2.92U
.ENDS rf2p_512x64_4_50CDWL
****
.SUBCKT rf2p_512x64_4_50CDWR BLA BLA_ BLB BLB_ DW DWWR DW_ GTP YP YP0 YP1 YP2
+  YP3 VSS VDD
** rf2p_512x64_4_50CDWR: 14 flat devices **
m1 BLB YI VDD VDD P L=0.18U W=1.56U
m10 GTPIN N18 GTP VDD P L=0.18U W=0.64U
m11 GTP YP GTPIN VSS N L=0.18U W=0.3U
m12 N18 YP VDD VDD P L=0.18U W=0.47U
m13 N18 YP VSS VSS N L=0.18U W=0.22U
m14 VSS N18 GTPIN VSS N L=0.18U W=0.22U
m2 BLB_ YI VDD VDD P L=0.18U W=1.56U
m3 YI YIIN VDD VDD P L=0.18U W=3.2U
m4 YI YIIN VSS VSS N L=0.18U W=1.5U
m5 YIIN GTPIN VDD VDD P L=0.18U W=1.43U
m6 YIIN GTPIN VSS VSS N L=0.18U W=0.67U
m7 BLB YI BLB_ VDD P L=0.18U W=1.56U
m8 DW_ YI BLB VSS N L=0.18U W=2.92U
m9 DW YI BLB_ VSS N L=0.18U W=2.92U
.ENDS rf2p_512x64_4_50CDWR
****
.SUBCKT rf2p_512x64_4_50CDW_MUX_UP BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 DWWR DWWR_0 DWWR_1
+  DWWR_2 GTP YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CDW_MUX_UP: 56 flat devices **
XI1 BLA BLA_ BLB BLB_ DWWR DWWR DWWR_0 GTP YP0 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CDWL
XI2 BLA_0 BLA__0 BLB_0 BLB__0 DWWR DWWR_0 DWWR_0 GTP YP1 YP0 YP1 YP2 YP3 VSS
+  VDD rf2p_512x64_4_50CDWR
XI3 BLA_1 BLA__1 BLB_1 BLB__1 DWWR DWWR_1 DWWR_0 GTP YP2 YP0 YP1 YP2 YP3 VSS
+  VDD rf2p_512x64_4_50CDWL
XI4 BLA_2 BLA__2 BLB_2 BLB__2 DWWR DWWR_2 DWWR_0 GTP YP3 YP0 YP1 YP2 YP3 VSS
+  VDD rf2p_512x64_4_50CDWR
.ENDS rf2p_512x64_4_50CDW_MUX_UP
****
.SUBCKT rf2p_512x64_4_50WR_MUX_UP_M BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D GTP GTP_0 WEI YP0
+  YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50WR_MUX_UP_M: 97 flat devices **
XI0_0 D DWA DWA_ GTP WEI VSS VDD rf2p_512x64_4_50WR
XI0_1 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 DWA DWA_ VSS VSS GTP_0 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CDW_MUX_UP
.ENDS rf2p_512x64_4_50WR_MUX_UP_M
****
.SUBCKT rf2p_512x64_4_50CCG BLA BLA_ BLB BLB_ WLA WLB VSS VDD
** rf2p_512x64_4_50CCG: 8 flat devices **
m1 BLB WLB CORED VSS N L=0.18U W=0.42U
m2 BLB_ WLB CORED_ VSS N L=0.18U W=0.42U
m3 BLA WLA CORED VSS N L=0.18U W=0.42U
m4 BLA_ WLA CORED_ VSS N L=0.18U W=0.42U
m5 CORED_ CORED VDD VDD P L=0.18U W=0.22U
m6 CORED_ CORED VSS VSS N L=0.18U W=1.49U
m7 CORED CORED_ VDD VDD P L=0.18U W=0.22U
m8 CORED CORED_ VSS VSS N L=0.18U W=1.49U
.ENDS rf2p_512x64_4_50CCG
****
.SUBCKT rf2p_512x64_4_50CCG2 BLA BLA_ BLB BLB_ WLA WLA_0 WLB WLB_0 VSS VDD
** rf2p_512x64_4_50CCG2: 16 flat devices **
XI0 BLA BLA_ BLB BLB_ WLA WLB VSS VDD rf2p_512x64_4_50CCG
XI1 BLA BLA_ BLB BLB_ WLA_0 WLB_0 VSS VDD rf2p_512x64_4_50CCG
.ENDS rf2p_512x64_4_50CCG2
****
.SUBCKT rf2p_512x64_4_50HCCMWG BLA BLA_ BLB BLB_ WLA0 WLA1 WLB0 WLB1 VSS VDD
** rf2p_512x64_4_50HCCMWG: 16 flat devices **
m1 N12 WLB0 CCMWG0-CORED VSS N L=0.18U W=0.42U
m10 N21 WLB1 CCMWG1-CORED_ VSS N L=0.18U W=0.42U
m11 N23 WLA1 CCMWG1-CORED VSS N L=0.18U W=0.42U
m12 N24 WLA1 CCMWG1-CORED_ VSS N L=0.18U W=0.42U
m13 CCMWG1-CORED_ CCMWG1-CORED VDD VDD P L=0.18U W=0.22U
m14 CCMWG1-CORED_ CCMWG1-CORED VSS VSS N L=0.18U W=1.49U
m15 CCMWG1-CORED CCMWG1-CORED_ VDD VDD P L=0.18U W=0.22U
m16 CCMWG1-CORED CCMWG1-CORED_ VSS VSS N L=0.18U W=1.49U
m2 N11 WLB0 CCMWG0-CORED_ VSS N L=0.18U W=0.42U
m3 N13 WLA0 CCMWG0-CORED VSS N L=0.18U W=0.42U
m4 N14 WLA0 CCMWG0-CORED_ VSS N L=0.18U W=0.42U
m5 CCMWG0-CORED_ CCMWG0-CORED VDD VDD P L=0.18U W=0.22U
m6 CCMWG0-CORED_ CCMWG0-CORED VSS VSS N L=0.18U W=1.49U
m7 CCMWG0-CORED CCMWG0-CORED_ VDD VDD P L=0.18U W=0.22U
m8 CCMWG0-CORED CCMWG0-CORED_ VSS VSS N L=0.18U W=1.49U
m9 N22 WLB1 CCMWG1-CORED VSS N L=0.18U W=0.42U
.ENDS rf2p_512x64_4_50HCCMWG
****
.SUBCKT rf2p_512x64_4_50CC_COL_HCCMWG BLA BLA_ BLB BLB_ WLA WLA0 WLA1 WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72
+  WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82
+  WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92
+  WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102
+  WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111
+  WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120
+  WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1
+  WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 VSS VDD
** rf2p_512x64_4_50CC_COL_HCCMWG: 1040 flat devices **
XI0 BLA_ BLA BLB_ BLB WLA WLA_0 WLB WLB_0 VSS VDD rf2p_512x64_4_50CCG2
XI1 BLA_ BLA BLB_ BLB WLA_1 WLA_2 WLB_1 WLB_2 VSS VDD rf2p_512x64_4_50CCG2
XI10 BLA_ BLA BLB_ BLB WLA_19 WLA_20 WLB_19 WLB_20 VSS VDD
+  rf2p_512x64_4_50CCG2
XI11 BLA_ BLA BLB_ BLB WLA_21 WLA_22 WLB_21 WLB_22 VSS VDD
+  rf2p_512x64_4_50CCG2
XI12 BLA_ BLA BLB_ BLB WLA_23 WLA_24 WLB_23 WLB_24 VSS VDD
+  rf2p_512x64_4_50CCG2
XI13 BLA_ BLA BLB_ BLB WLA_25 WLA_26 WLB_25 WLB_26 VSS VDD
+  rf2p_512x64_4_50CCG2
XI14 BLA_ BLA BLB_ BLB WLA_27 WLA_28 WLB_27 WLB_28 VSS VDD
+  rf2p_512x64_4_50CCG2
XI15 BLA_ BLA BLB_ BLB WLA_29 WLA_30 WLB_29 WLB_30 VSS VDD
+  rf2p_512x64_4_50CCG2
XI17 BLA BLA_ BLB BLB_ WLA_31 WLA_32 WLB_31 WLB_32 VSS VDD
+  rf2p_512x64_4_50CCG2
XI18 BLA BLA_ BLB BLB_ WLA_33 WLA_34 WLB_33 WLB_34 VSS VDD
+  rf2p_512x64_4_50CCG2
XI19 BLA BLA_ BLB BLB_ WLA_35 WLA_36 WLB_35 WLB_36 VSS VDD
+  rf2p_512x64_4_50CCG2
XI2 BLA_ BLA BLB_ BLB WLA_3 WLA_4 WLB_3 WLB_4 VSS VDD rf2p_512x64_4_50CCG2
XI20 BLA BLA_ BLB BLB_ WLA_37 WLA_38 WLB_37 WLB_38 VSS VDD
+  rf2p_512x64_4_50CCG2
XI21 BLA BLA_ BLB BLB_ WLA_39 WLA_40 WLB_39 WLB_40 VSS VDD
+  rf2p_512x64_4_50CCG2
XI22 BLA BLA_ BLB BLB_ WLA_41 WLA_42 WLB_41 WLB_42 VSS VDD
+  rf2p_512x64_4_50CCG2
XI23 BLA BLA_ BLB BLB_ WLA_43 WLA_44 WLB_43 WLB_44 VSS VDD
+  rf2p_512x64_4_50CCG2
XI24 BLA BLA_ BLB BLB_ WLA_45 WLA_46 WLB_45 WLB_46 VSS VDD
+  rf2p_512x64_4_50CCG2
XI25 BLA BLA_ BLB BLB_ WLA_47 WLA_48 WLB_47 WLB_48 VSS VDD
+  rf2p_512x64_4_50CCG2
XI26 BLA BLA_ BLB BLB_ WLA_49 WLA_50 WLB_49 WLB_50 VSS VDD
+  rf2p_512x64_4_50CCG2
XI27 BLA BLA_ BLB BLB_ WLA_51 WLA_52 WLB_51 WLB_52 VSS VDD
+  rf2p_512x64_4_50CCG2
XI28 BLA BLA_ BLB BLB_ WLA_53 WLA_54 WLB_53 WLB_54 VSS VDD
+  rf2p_512x64_4_50CCG2
XI29 BLA BLA_ BLB BLB_ WLA_55 WLA_56 WLB_55 WLB_56 VSS VDD
+  rf2p_512x64_4_50CCG2
XI3 BLA_ BLA BLB_ BLB WLA_5 WLA_6 WLB_5 WLB_6 VSS VDD rf2p_512x64_4_50CCG2
XI30 BLA BLA_ BLB BLB_ WLA_57 WLA_58 WLB_57 WLB_58 VSS VDD
+  rf2p_512x64_4_50CCG2
XI31 BLA BLA_ BLB BLB_ WLA_59 WLA_60 WLB_59 WLB_60 VSS VDD
+  rf2p_512x64_4_50CCG2
XI32 BLA BLA_ BLB BLB_ WLA_61 WLA_62 WLB_61 WLB_62 VSS VDD
+  rf2p_512x64_4_50CCG2
XI33 BLA_ BLA BLB_ BLB WLA0 WLA1 WLB0 WLB1 VSS VDD rf2p_512x64_4_50HCCMWG
XI34 BLA_ BLA BLB_ BLB WLA_63 WLA_64 WLB_63 WLB_64 VSS VDD
+  rf2p_512x64_4_50CCG2
XI35 BLA_ BLA BLB_ BLB WLA_65 WLA_66 WLB_65 WLB_66 VSS VDD
+  rf2p_512x64_4_50CCG2
XI36 BLA_ BLA BLB_ BLB WLA_67 WLA_68 WLB_67 WLB_68 VSS VDD
+  rf2p_512x64_4_50CCG2
XI37 BLA_ BLA BLB_ BLB WLA_69 WLA_70 WLB_69 WLB_70 VSS VDD
+  rf2p_512x64_4_50CCG2
XI38 BLA_ BLA BLB_ BLB WLA_71 WLA_72 WLB_71 WLB_72 VSS VDD
+  rf2p_512x64_4_50CCG2
XI39 BLA_ BLA BLB_ BLB WLA_73 WLA_74 WLB_73 WLB_74 VSS VDD
+  rf2p_512x64_4_50CCG2
XI4 BLA_ BLA BLB_ BLB WLA_7 WLA_8 WLB_7 WLB_8 VSS VDD rf2p_512x64_4_50CCG2
XI40 BLA_ BLA BLB_ BLB WLA_75 WLA_76 WLB_75 WLB_76 VSS VDD
+  rf2p_512x64_4_50CCG2
XI41 BLA_ BLA BLB_ BLB WLA_77 WLA_78 WLB_77 WLB_78 VSS VDD
+  rf2p_512x64_4_50CCG2
XI42 BLA_ BLA BLB_ BLB WLA_79 WLA_80 WLB_79 WLB_80 VSS VDD
+  rf2p_512x64_4_50CCG2
XI43 BLA_ BLA BLB_ BLB WLA_81 WLA_82 WLB_81 WLB_82 VSS VDD
+  rf2p_512x64_4_50CCG2
XI44 BLA_ BLA BLB_ BLB WLA_83 WLA_84 WLB_83 WLB_84 VSS VDD
+  rf2p_512x64_4_50CCG2
XI45 BLA_ BLA BLB_ BLB WLA_85 WLA_86 WLB_85 WLB_86 VSS VDD
+  rf2p_512x64_4_50CCG2
XI46 BLA_ BLA BLB_ BLB WLA_87 WLA_88 WLB_87 WLB_88 VSS VDD
+  rf2p_512x64_4_50CCG2
XI47 BLA_ BLA BLB_ BLB WLA_89 WLA_90 WLB_89 WLB_90 VSS VDD
+  rf2p_512x64_4_50CCG2
XI48 BLA_ BLA BLB_ BLB WLA_91 WLA_92 WLB_91 WLB_92 VSS VDD
+  rf2p_512x64_4_50CCG2
XI5 BLA_ BLA BLB_ BLB WLA_9 WLA_10 WLB_9 WLB_10 VSS VDD rf2p_512x64_4_50CCG2
XI50 BLA BLA_ BLB BLB_ WLA_93 WLA_94 WLB_93 WLB_94 VSS VDD
+  rf2p_512x64_4_50CCG2
XI51 BLA BLA_ BLB BLB_ WLA_95 WLA_96 WLB_95 WLB_96 VSS VDD
+  rf2p_512x64_4_50CCG2
XI52 BLA BLA_ BLB BLB_ WLA_97 WLA_98 WLB_97 WLB_98 VSS VDD
+  rf2p_512x64_4_50CCG2
XI53 BLA BLA_ BLB BLB_ WLA_99 WLA_100 WLB_99 WLB_100 VSS VDD
+  rf2p_512x64_4_50CCG2
XI54 BLA BLA_ BLB BLB_ WLA_101 WLA_102 WLB_101 WLB_102 VSS VDD
+  rf2p_512x64_4_50CCG2
XI55 BLA BLA_ BLB BLB_ WLA_103 WLA_104 WLB_103 WLB_104 VSS VDD
+  rf2p_512x64_4_50CCG2
XI56 BLA BLA_ BLB BLB_ WLA_105 WLA_106 WLB_105 WLB_106 VSS VDD
+  rf2p_512x64_4_50CCG2
XI57 BLA BLA_ BLB BLB_ WLA_107 WLA_108 WLB_107 WLB_108 VSS VDD
+  rf2p_512x64_4_50CCG2
XI58 BLA BLA_ BLB BLB_ WLA_109 WLA_110 WLB_109 WLB_110 VSS VDD
+  rf2p_512x64_4_50CCG2
XI59 BLA BLA_ BLB BLB_ WLA_111 WLA_112 WLB_111 WLB_112 VSS VDD
+  rf2p_512x64_4_50CCG2
XI6 BLA_ BLA BLB_ BLB WLA_11 WLA_12 WLB_11 WLB_12 VSS VDD rf2p_512x64_4_50CCG2
XI60 BLA BLA_ BLB BLB_ WLA_113 WLA_114 WLB_113 WLB_114 VSS VDD
+  rf2p_512x64_4_50CCG2
XI61 BLA BLA_ BLB BLB_ WLA_115 WLA_116 WLB_115 WLB_116 VSS VDD
+  rf2p_512x64_4_50CCG2
XI62 BLA BLA_ BLB BLB_ WLA_117 WLA_118 WLB_117 WLB_118 VSS VDD
+  rf2p_512x64_4_50CCG2
XI63 BLA BLA_ BLB BLB_ WLA_119 WLA_120 WLB_119 WLB_120 VSS VDD
+  rf2p_512x64_4_50CCG2
XI64 BLA BLA_ BLB BLB_ WLA_121 WLA_122 WLB_121 WLB_122 VSS VDD
+  rf2p_512x64_4_50CCG2
XI65 BLA BLA_ BLB BLB_ WLA_123 WLA_124 WLB_123 WLB_124 VSS VDD
+  rf2p_512x64_4_50CCG2
XI66 BLA BLA_ BLB BLB_ WLA_125 WLA_126 WLB_125 WLB_126 VSS VDD
+  rf2p_512x64_4_50CCG2
XI7 BLA_ BLA BLB_ BLB WLA_13 WLA_14 WLB_13 WLB_14 VSS VDD rf2p_512x64_4_50CCG2
XI8 BLA_ BLA BLB_ BLB WLA_15 WLA_16 WLB_15 WLB_16 VSS VDD rf2p_512x64_4_50CCG2
XI9 BLA_ BLA BLB_ BLB WLA_17 WLA_18 WLB_17 WLB_18 VSS VDD rf2p_512x64_4_50CCG2
.ENDS rf2p_512x64_4_50CC_COL_HCCMWG
****
.SUBCKT rf2p_512x64_4_50SA DR DR_ GTPSA_ GTPTOSA Q VSS VDD
** rf2p_512x64_4_50SA: 33 flat devices **
d30 VSS Q DN 0.3364P 2.32U
m1 SD N19 DR VDD P L=0.18U W=0.44U
m10 SI_ SD_ VDD VDD P L=0.18U W=0.47U
m11 SI_ SD_ VSS VSS N L=0.18U W=0.22U
m12 SDB SI VSS VSS N L=0.18U W=1.7U
m13 SDB_ SI_ VSS VSS N L=0.18U W=1.7U
m14 SDB_ SDB VDD VDD P L=0.18U W=1.36U
m15 SDB_ SDB VSS VSS N L=0.18U W=0.22U
m16 SDB SDB_ VDD VDD P L=0.18U W=0.47U
m17 SDB SDB_ VSS VSS N L=0.18U W=0.22U
m18 Q SDB_ VDD VDD P L=0.18U W=3.82U
m19 Q SDB_ VSS VSS N L=0.18U W=1.8U
m2 DR_ N19 SD_ VDD P L=0.18U W=0.44U
m20 DR_ PRE VDD VDD P L=0.18U W=1.16U
m21 DR PRE VDD VDD P L=0.18U W=1.16U
m22 DR PRE DR_ VDD P L=0.18U W=1.16U
m23 N38 GTPTOSA VDD VDD P L=0.18U W=0.47U
m24 N38 GTPTOSA VSS VSS N L=0.18U W=0.22U
m25 N19 GTPSA_ VDD VDD P L=0.18U W=0.51U
m26 N19 GTPSA_ VSS VSS N L=0.18U W=0.24U
m27 PRE N38 VDD VDD P L=0.18U W=1.04U
m28 PRE N38 VSS VSS N L=0.18U W=0.49U
m29 SD VSS SD_ VSS N L=0.18U W=0.84U
m3 SD SD_ VDD VDD P L=0.18U W=0.22U
m31 SRC GTPSA_ VDD VSS N L=0.18U W=0.44U
m32 SD_ VDD SD VDD P L=0.18U W=0.22U
m33 SD_ VDD SD VDD P L=0.18U W=0.44U
m4 SD_ SD VDD VDD P L=0.18U W=0.22U
m5 SRC N19 VSS VSS N L=0.18U W=0.84U
m6 SD SD_ SRC VSS N L=0.18U W=0.84U
m7 SD_ SD SRC VSS N L=0.18U W=0.84U
m8 SI SD VDD VDD P L=0.18U W=0.47U
m9 SI SD VSS VSS N L=0.18U W=0.22U
.ENDS rf2p_512x64_4_50SA
****
.SUBCKT rf2p_512x64_4_50CDRL BLA BLA_ BLB BLB_ DR DRSA DR_ GTP GTPTOSA YP YP0
+  YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CDRL: 14 flat devices **
m1 BLA YI VDD VDD P L=0.18U W=1.55U
m10 GTPIN YPIN GTP VDD P L=0.18U W=0.47U
m11 GTP YP GTPIN VSS N L=0.18U W=0.22U
m12 YPIN YP VDD VDD P L=0.18U W=0.7U
m13 YPIN YP VSS VSS N L=0.18U W=0.33U
m14 VSS YPIN GTPIN VSS N L=0.18U W=0.22U
m2 BLA_ YI VDD VDD P L=0.18U W=1.55U
m3 YI YIIN VDD VDD P L=0.18U W=1.41U
m4 YI YIIN VSS VSS N L=0.18U W=0.66U
m5 YIIN GTPIN VDD VDD P L=0.18U W=0.47U
m6 YIIN GTPIN VSS VSS N L=0.18U W=0.22U
m7 BLA YI BLA_ VDD P L=0.18U W=1.55U
m8 BLA YPIN DR VDD P L=0.18U W=1.35U
m9 BLA_ YPIN DR_ VDD P L=0.18U W=1.35U
.ENDS rf2p_512x64_4_50CDRL
****
.SUBCKT rf2p_512x64_4_50CDRR BLA BLA_ BLB BLB_ DR DRSA DR_ GTP GTPTOSA YP YP0
+  YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CDRR: 14 flat devices **
m1 BLA YI VDD VDD P L=0.18U W=1.55U
m10 GTPIN YPIN GTP VDD P L=0.18U W=0.47U
m11 GTP YP GTPIN VSS N L=0.18U W=0.22U
m12 YPIN YP VDD VDD P L=0.18U W=0.7U
m13 YPIN YP VSS VSS N L=0.18U W=0.33U
m14 VSS YPIN GTPIN VSS N L=0.18U W=0.22U
m2 BLA_ YI VDD VDD P L=0.18U W=1.55U
m3 YI YIIN VDD VDD P L=0.18U W=1.41U
m4 YI YIIN VSS VSS N L=0.18U W=0.66U
m5 YIIN GTPIN VDD VDD P L=0.18U W=0.47U
m6 YIIN GTPIN VSS VSS N L=0.18U W=0.22U
m7 BLA YI BLA_ VDD P L=0.18U W=1.55U
m8 BLA YPIN DR_ VDD P L=0.18U W=1.35U
m9 BLA_ YPIN DR VDD P L=0.18U W=1.35U
.ENDS rf2p_512x64_4_50CDRR
****
.SUBCKT rf2p_512x64_4_50CDR_MUX_UP BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 DRSA DRSA_0 DRSA_1
+  DRSA_2 GTP GTPTOSA GTPTOSA_0 GTPTOSA_1 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CDR_MUX_UP: 56 flat devices **
XI1 BLA BLA_ BLB BLB_ DRSA DRSA DRSA_0 GTP GTP YP0 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CDRL
XI2 BLA_0 BLA__0 BLB_0 BLB__0 DRSA DRSA_0 DRSA_0 GTP GTPTOSA YP1 YP0 YP1 YP2
+  YP3 VSS VDD rf2p_512x64_4_50CDRR
XI3 BLA_1 BLA__1 BLB_1 BLB__1 DRSA DRSA_1 DRSA_0 GTP GTPTOSA_0 YP2 YP0 YP1 YP2
+  YP3 VSS VDD rf2p_512x64_4_50CDRL
XI4 BLA_2 BLA__2 BLB_2 BLB__2 DRSA DRSA_2 DRSA_0 GTP GTPTOSA_1 YP3 YP0 YP1 YP2
+  YP3 VSS VDD rf2p_512x64_4_50CDRR
.ENDS rf2p_512x64_4_50CDR_MUX_UP
****
.SUBCKT rf2p_512x64_4_50RD_MUX_UP BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 GTP GTPSA Q YP0 YP1
+  YP2 YP3 VSS VDD
** rf2p_512x64_4_50RD_MUX_UP: 89 flat devices **
XI0_0 DR DR_ GTPSA GTP Q VSS VDD rf2p_512x64_4_50SA
XI0_1 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 DR DR_ VSS VSS GTP VSS VSS VSS YP0 YP1 YP2 YP3
+  VSS VDD rf2p_512x64_4_50CDR_MUX_UP
.ENDS rf2p_512x64_4_50RD_MUX_UP
****
.SUBCKT rf2p_512x64_4_50BCOL_M_UP D GTP GTPSA GTP_0 GTP_1 Q WEI WLA WLA0 WLA1
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31
+  WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41
+  WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51
+  WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61
+  WLA_62 WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71
+  WLA_72 WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81
+  WLA_82 WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91
+  WLA_92 WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101
+  WLA_102 WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110
+  WLA_111 WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119
+  WLA_120 WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72
+  WLB_73 WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82
+  WLB_83 WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92
+  WLB_93 WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102
+  WLB_103 WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111
+  WLB_112 WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120
+  WLB_121 WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2
+  YP2_0 YP3 YP3_0 VSS VDD
** rf2p_512x64_4_50BCOL_M_UP: 4346 flat devices **
XI0_0 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 D GTP GTP_0 WEI YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50WR_MUX_UP_M
XI0_1 BLA_ BLA BLB_ BLB WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66
+  WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76
+  WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86
+  WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96
+  WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI0_2 BLA_ BLA BLA__0 BLA__1 BLA__2 BLA_0 BLA_1 BLA_2 BLB_ BLB BLB__0 BLB__1
+  BLB__2 BLB_0 BLB_1 BLB_2 GTP_1 GTPSA Q YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD
+  rf2p_512x64_4_50RD_MUX_UP
XI1_1 BLA__0 BLA_0 BLB__0 BLB_0 WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI2_1 BLA__1 BLA_1 BLB__1 BLB_1 WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI3_1 BLA__2 BLA_2 BLB__2 BLB_2 WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
.ENDS rf2p_512x64_4_50BCOL_M_UP
****
.SUBCKT rf2p_512x64_4_50CDW_MUX_DN BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 DWWR DWWR_0 DWWR_1
+  DWWR_2 GTP YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CDW_MUX_DN: 56 flat devices **
XI1 BLA BLA_ BLB BLB_ DWWR DWWR DWWR_0 GTP YP3 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CDWL
XI2 BLA_0 BLA__0 BLB_0 BLB__0 DWWR DWWR_0 DWWR_0 GTP YP2 YP0 YP1 YP2 YP3 VSS
+  VDD rf2p_512x64_4_50CDWR
XI3 BLA_1 BLA__1 BLB_1 BLB__1 DWWR DWWR_1 DWWR_0 GTP YP1 YP0 YP1 YP2 YP3 VSS
+  VDD rf2p_512x64_4_50CDWL
XI4 BLA_2 BLA__2 BLB_2 BLB__2 DWWR DWWR_2 DWWR_0 GTP YP0 YP0 YP1 YP2 YP3 VSS
+  VDD rf2p_512x64_4_50CDWR
.ENDS rf2p_512x64_4_50CDW_MUX_DN
****
.SUBCKT rf2p_512x64_4_50WR_MUX_DN_M BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D GTP GTP_0 WEI YP0
+  YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50WR_MUX_DN_M: 97 flat devices **
XI0_0 D DWA DWA_ GTP WEI VSS VDD rf2p_512x64_4_50WR
XI0_1 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 DWA DWA_ VSS VSS GTP_0 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CDW_MUX_DN
.ENDS rf2p_512x64_4_50WR_MUX_DN_M
****
.SUBCKT rf2p_512x64_4_50CDR_MUX_DN BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 DRSA DRSA_0 DRSA_1
+  DRSA_2 GTP GTPTOSA GTPTOSA_0 GTPTOSA_1 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CDR_MUX_DN: 56 flat devices **
XI1 BLA BLA_ BLB BLB_ DRSA DRSA DRSA_0 GTP GTP YP3 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CDRL
XI2 BLA_0 BLA__0 BLB_0 BLB__0 DRSA DRSA_0 DRSA_0 GTP GTPTOSA YP2 YP0 YP1 YP2
+  YP3 VSS VDD rf2p_512x64_4_50CDRR
XI3 BLA_1 BLA__1 BLB_1 BLB__1 DRSA DRSA_1 DRSA_0 GTP GTPTOSA_0 YP1 YP0 YP1 YP2
+  YP3 VSS VDD rf2p_512x64_4_50CDRL
XI4 BLA_2 BLA__2 BLB_2 BLB__2 DRSA DRSA_2 DRSA_0 GTP GTPTOSA_1 YP0 YP0 YP1 YP2
+  YP3 VSS VDD rf2p_512x64_4_50CDRR
.ENDS rf2p_512x64_4_50CDR_MUX_DN
****
.SUBCKT rf2p_512x64_4_50RD_MUX_DN BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1
+  BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 GTP GTPSA Q YP0 YP1
+  YP2 YP3 VSS VDD
** rf2p_512x64_4_50RD_MUX_DN: 89 flat devices **
XI0_0 DR DR_ GTPSA GTP Q VSS VDD rf2p_512x64_4_50SA
XI0_1 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 DR DR_ VSS VSS GTP VSS VSS VSS YP0 YP1 YP2 YP3
+  VSS VDD rf2p_512x64_4_50CDR_MUX_DN
.ENDS rf2p_512x64_4_50RD_MUX_DN
****
.SUBCKT rf2p_512x64_4_50BCOL_M_DN D GTP GTPSA GTP_0 GTP_1 Q WEI WLA WLA0 WLA1
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31
+  WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41
+  WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51
+  WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61
+  WLA_62 WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71
+  WLA_72 WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81
+  WLA_82 WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91
+  WLA_92 WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101
+  WLA_102 WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110
+  WLA_111 WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119
+  WLA_120 WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72
+  WLB_73 WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82
+  WLB_83 WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92
+  WLB_93 WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102
+  WLB_103 WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111
+  WLB_112 WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120
+  WLB_121 WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2
+  YP2_0 YP3 YP3_0 VSS VDD
** rf2p_512x64_4_50BCOL_M_DN: 4346 flat devices **
XI0_0 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 D GTP GTP_0 WEI YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50WR_MUX_DN_M
XI0_1 BLA_ BLA BLB_ BLB WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66
+  WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76
+  WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86
+  WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96
+  WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI0_2 BLA_ BLA BLA__0 BLA__1 BLA__2 BLA_0 BLA_1 BLA_2 BLB_ BLB BLB__0 BLB__1
+  BLB__2 BLB_0 BLB_1 BLB_2 GTP_1 GTPSA Q YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD
+  rf2p_512x64_4_50RD_MUX_DN
XI1_1 BLA__0 BLA_0 BLB__0 BLB_0 WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI2_1 BLA__1 BLA_1 BLB__1 BLB_1 WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI3_1 BLA__2 BLA_2 BLB__2 BLB_2 WLA WLA0 WLA1 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB1 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
.ENDS rf2p_512x64_4_50BCOL_M_DN
****
.SUBCKT rf2p_512x64_4_50FLMWG BLA BLA_ BLB BLB_ MWLAL MWLAR MWLBL MWLBR VSS
+  VDD
** rf2p_512x64_4_50FLMWG: 16 flat devices **
m1 N15 MWLBR CORED0_ VSS N L=0.18U W=0.42U
m10 CORED0_ CORED0 N25 VSS N L=0.18U W=1.49U
m11 CORED0 CORED0_ VDD VDD P L=0.18U W=0.22U
m12 CORED0 CORED0_ N25 VSS N L=0.18U W=1.49U
m13 CORED1_ CORED1 VDD VDD P L=0.18U W=0.22U
m14 CORED1_ CORED1 N26 VSS N L=0.18U W=1.49U
m15 CORED1 CORED1_ VDD VDD P L=0.18U W=0.22U
m16 CORED1 CORED1_ N26 VSS N L=0.18U W=1.49U
m2 N13 MWLBR CORED0 VSS N L=0.18U W=0.42U
m3 N23 MWLAR CORED0_ VSS N L=0.18U W=0.42U
m4 N14 MWLAR CORED0 VSS N L=0.18U W=0.42U
m5 N19 MWLBR CORED1 VSS N L=0.18U W=0.42U
m6 N18 MWLBR CORED1_ VSS N L=0.18U W=0.42U
m7 N20 MWLAR CORED1 VSS N L=0.18U W=0.42U
m8 N24 MWLAR CORED1_ VSS N L=0.18U W=0.42U
m9 CORED0_ CORED0 VDD VDD P L=0.18U W=0.22U
.ENDS rf2p_512x64_4_50FLMWG
****
.SUBCKT rf2p_512x64_4_50CC_COL_FLMWG BLA BLA_ BLB BLB_ MWLAL MWLAR MWLBL MWLBR
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30
+  WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40
+  WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50
+  WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60
+  WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70
+  WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80
+  WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90
+  WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100
+  WLA_101 WLA_102 WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109
+  WLA_110 WLA_111 WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118
+  WLA_119 WLA_120 WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72
+  WLB_73 WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82
+  WLB_83 WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92
+  WLB_93 WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102
+  WLB_103 WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111
+  WLB_112 WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120
+  WLB_121 WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 VSS VDD
** rf2p_512x64_4_50CC_COL_FLMWG: 1040 flat devices **
XI0 BLA_ BLA BLB_ BLB WLA WLA_0 WLB WLB_0 VSS VDD rf2p_512x64_4_50CCG2
XI1 BLA_ BLA BLB_ BLB WLA_1 WLA_2 WLB_1 WLB_2 VSS VDD rf2p_512x64_4_50CCG2
XI10 BLA_ BLA BLB_ BLB WLA_19 WLA_20 WLB_19 WLB_20 VSS VDD
+  rf2p_512x64_4_50CCG2
XI11 BLA_ BLA BLB_ BLB WLA_21 WLA_22 WLB_21 WLB_22 VSS VDD
+  rf2p_512x64_4_50CCG2
XI12 BLA_ BLA BLB_ BLB WLA_23 WLA_24 WLB_23 WLB_24 VSS VDD
+  rf2p_512x64_4_50CCG2
XI13 BLA_ BLA BLB_ BLB WLA_25 WLA_26 WLB_25 WLB_26 VSS VDD
+  rf2p_512x64_4_50CCG2
XI14 BLA_ BLA BLB_ BLB WLA_27 WLA_28 WLB_27 WLB_28 VSS VDD
+  rf2p_512x64_4_50CCG2
XI15 BLA_ BLA BLB_ BLB WLA_29 WLA_30 WLB_29 WLB_30 VSS VDD
+  rf2p_512x64_4_50CCG2
XI17 BLA BLA_ BLB BLB_ WLA_31 WLA_32 WLB_31 WLB_32 VSS VDD
+  rf2p_512x64_4_50CCG2
XI18 BLA BLA_ BLB BLB_ WLA_33 WLA_34 WLB_33 WLB_34 VSS VDD
+  rf2p_512x64_4_50CCG2
XI19 BLA BLA_ BLB BLB_ WLA_35 WLA_36 WLB_35 WLB_36 VSS VDD
+  rf2p_512x64_4_50CCG2
XI2 BLA_ BLA BLB_ BLB WLA_3 WLA_4 WLB_3 WLB_4 VSS VDD rf2p_512x64_4_50CCG2
XI20 BLA BLA_ BLB BLB_ WLA_37 WLA_38 WLB_37 WLB_38 VSS VDD
+  rf2p_512x64_4_50CCG2
XI21 BLA BLA_ BLB BLB_ WLA_39 WLA_40 WLB_39 WLB_40 VSS VDD
+  rf2p_512x64_4_50CCG2
XI22 BLA BLA_ BLB BLB_ WLA_41 WLA_42 WLB_41 WLB_42 VSS VDD
+  rf2p_512x64_4_50CCG2
XI23 BLA BLA_ BLB BLB_ WLA_43 WLA_44 WLB_43 WLB_44 VSS VDD
+  rf2p_512x64_4_50CCG2
XI24 BLA BLA_ BLB BLB_ WLA_45 WLA_46 WLB_45 WLB_46 VSS VDD
+  rf2p_512x64_4_50CCG2
XI25 BLA BLA_ BLB BLB_ WLA_47 WLA_48 WLB_47 WLB_48 VSS VDD
+  rf2p_512x64_4_50CCG2
XI26 BLA BLA_ BLB BLB_ WLA_49 WLA_50 WLB_49 WLB_50 VSS VDD
+  rf2p_512x64_4_50CCG2
XI27 BLA BLA_ BLB BLB_ WLA_51 WLA_52 WLB_51 WLB_52 VSS VDD
+  rf2p_512x64_4_50CCG2
XI28 BLA BLA_ BLB BLB_ WLA_53 WLA_54 WLB_53 WLB_54 VSS VDD
+  rf2p_512x64_4_50CCG2
XI29 BLA BLA_ BLB BLB_ WLA_55 WLA_56 WLB_55 WLB_56 VSS VDD
+  rf2p_512x64_4_50CCG2
XI3 BLA_ BLA BLB_ BLB WLA_5 WLA_6 WLB_5 WLB_6 VSS VDD rf2p_512x64_4_50CCG2
XI30 BLA BLA_ BLB BLB_ WLA_57 WLA_58 WLB_57 WLB_58 VSS VDD
+  rf2p_512x64_4_50CCG2
XI31 BLA BLA_ BLB BLB_ WLA_59 WLA_60 WLB_59 WLB_60 VSS VDD
+  rf2p_512x64_4_50CCG2
XI32 BLA BLA_ BLB BLB_ WLA_61 WLA_62 WLB_61 WLB_62 VSS VDD
+  rf2p_512x64_4_50CCG2
XI33 BLA_ BLA BLB_ BLB MWLAL MWLAR MWLBL MWLBR VSS VDD rf2p_512x64_4_50FLMWG
XI34 BLA_ BLA BLB_ BLB WLA_63 WLA_64 WLB_63 WLB_64 VSS VDD
+  rf2p_512x64_4_50CCG2
XI35 BLA_ BLA BLB_ BLB WLA_65 WLA_66 WLB_65 WLB_66 VSS VDD
+  rf2p_512x64_4_50CCG2
XI36 BLA_ BLA BLB_ BLB WLA_67 WLA_68 WLB_67 WLB_68 VSS VDD
+  rf2p_512x64_4_50CCG2
XI37 BLA_ BLA BLB_ BLB WLA_69 WLA_70 WLB_69 WLB_70 VSS VDD
+  rf2p_512x64_4_50CCG2
XI38 BLA_ BLA BLB_ BLB WLA_71 WLA_72 WLB_71 WLB_72 VSS VDD
+  rf2p_512x64_4_50CCG2
XI39 BLA_ BLA BLB_ BLB WLA_73 WLA_74 WLB_73 WLB_74 VSS VDD
+  rf2p_512x64_4_50CCG2
XI4 BLA_ BLA BLB_ BLB WLA_7 WLA_8 WLB_7 WLB_8 VSS VDD rf2p_512x64_4_50CCG2
XI40 BLA_ BLA BLB_ BLB WLA_75 WLA_76 WLB_75 WLB_76 VSS VDD
+  rf2p_512x64_4_50CCG2
XI41 BLA_ BLA BLB_ BLB WLA_77 WLA_78 WLB_77 WLB_78 VSS VDD
+  rf2p_512x64_4_50CCG2
XI42 BLA_ BLA BLB_ BLB WLA_79 WLA_80 WLB_79 WLB_80 VSS VDD
+  rf2p_512x64_4_50CCG2
XI43 BLA_ BLA BLB_ BLB WLA_81 WLA_82 WLB_81 WLB_82 VSS VDD
+  rf2p_512x64_4_50CCG2
XI44 BLA_ BLA BLB_ BLB WLA_83 WLA_84 WLB_83 WLB_84 VSS VDD
+  rf2p_512x64_4_50CCG2
XI45 BLA_ BLA BLB_ BLB WLA_85 WLA_86 WLB_85 WLB_86 VSS VDD
+  rf2p_512x64_4_50CCG2
XI46 BLA_ BLA BLB_ BLB WLA_87 WLA_88 WLB_87 WLB_88 VSS VDD
+  rf2p_512x64_4_50CCG2
XI47 BLA_ BLA BLB_ BLB WLA_89 WLA_90 WLB_89 WLB_90 VSS VDD
+  rf2p_512x64_4_50CCG2
XI48 BLA_ BLA BLB_ BLB WLA_91 WLA_92 WLB_91 WLB_92 VSS VDD
+  rf2p_512x64_4_50CCG2
XI5 BLA_ BLA BLB_ BLB WLA_9 WLA_10 WLB_9 WLB_10 VSS VDD rf2p_512x64_4_50CCG2
XI50 BLA BLA_ BLB BLB_ WLA_93 WLA_94 WLB_93 WLB_94 VSS VDD
+  rf2p_512x64_4_50CCG2
XI51 BLA BLA_ BLB BLB_ WLA_95 WLA_96 WLB_95 WLB_96 VSS VDD
+  rf2p_512x64_4_50CCG2
XI52 BLA BLA_ BLB BLB_ WLA_97 WLA_98 WLB_97 WLB_98 VSS VDD
+  rf2p_512x64_4_50CCG2
XI53 BLA BLA_ BLB BLB_ WLA_99 WLA_100 WLB_99 WLB_100 VSS VDD
+  rf2p_512x64_4_50CCG2
XI54 BLA BLA_ BLB BLB_ WLA_101 WLA_102 WLB_101 WLB_102 VSS VDD
+  rf2p_512x64_4_50CCG2
XI55 BLA BLA_ BLB BLB_ WLA_103 WLA_104 WLB_103 WLB_104 VSS VDD
+  rf2p_512x64_4_50CCG2
XI56 BLA BLA_ BLB BLB_ WLA_105 WLA_106 WLB_105 WLB_106 VSS VDD
+  rf2p_512x64_4_50CCG2
XI57 BLA BLA_ BLB BLB_ WLA_107 WLA_108 WLB_107 WLB_108 VSS VDD
+  rf2p_512x64_4_50CCG2
XI58 BLA BLA_ BLB BLB_ WLA_109 WLA_110 WLB_109 WLB_110 VSS VDD
+  rf2p_512x64_4_50CCG2
XI59 BLA BLA_ BLB BLB_ WLA_111 WLA_112 WLB_111 WLB_112 VSS VDD
+  rf2p_512x64_4_50CCG2
XI6 BLA_ BLA BLB_ BLB WLA_11 WLA_12 WLB_11 WLB_12 VSS VDD rf2p_512x64_4_50CCG2
XI60 BLA BLA_ BLB BLB_ WLA_113 WLA_114 WLB_113 WLB_114 VSS VDD
+  rf2p_512x64_4_50CCG2
XI61 BLA BLA_ BLB BLB_ WLA_115 WLA_116 WLB_115 WLB_116 VSS VDD
+  rf2p_512x64_4_50CCG2
XI62 BLA BLA_ BLB BLB_ WLA_117 WLA_118 WLB_117 WLB_118 VSS VDD
+  rf2p_512x64_4_50CCG2
XI63 BLA BLA_ BLB BLB_ WLA_119 WLA_120 WLB_119 WLB_120 VSS VDD
+  rf2p_512x64_4_50CCG2
XI64 BLA BLA_ BLB BLB_ WLA_121 WLA_122 WLB_121 WLB_122 VSS VDD
+  rf2p_512x64_4_50CCG2
XI65 BLA BLA_ BLB BLB_ WLA_123 WLA_124 WLB_123 WLB_124 VSS VDD
+  rf2p_512x64_4_50CCG2
XI66 BLA BLA_ BLB BLB_ WLA_125 WLA_126 WLB_125 WLB_126 VSS VDD
+  rf2p_512x64_4_50CCG2
XI7 BLA_ BLA BLB_ BLB WLA_13 WLA_14 WLB_13 WLB_14 VSS VDD rf2p_512x64_4_50CCG2
XI8 BLA_ BLA BLB_ BLB WLA_15 WLA_16 WLB_15 WLB_16 VSS VDD rf2p_512x64_4_50CCG2
XI9 BLA_ BLA BLB_ BLB WLA_17 WLA_18 WLB_17 WLB_18 VSS VDD rf2p_512x64_4_50CCG2
.ENDS rf2p_512x64_4_50CC_COL_FLMWG
****
.SUBCKT rf2p_512x64_4_50BCOL_M_UP_3 D GTP GTPSA GTP_0 GTP_1 MWLAL MWLBL Q WEI
+  WLA WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30
+  WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40
+  WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50
+  WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60
+  WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70
+  WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80
+  WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90
+  WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100
+  WLA_101 WLA_102 WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109
+  WLA_110 WLA_111 WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118
+  WLA_119 WLA_120 WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31
+  WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41
+  WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51
+  WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61
+  WLB_62 WLB_63 WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71
+  WLB_72 WLB_73 WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81
+  WLB_82 WLB_83 WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91
+  WLB_92 WLB_93 WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101
+  WLB_102 WLB_103 WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110
+  WLB_111 WLB_112 WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119
+  WLB_120 WLB_121 WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0
+  YP2 YP2_0 YP3 YP3_0 VSS VDD
** rf2p_512x64_4_50BCOL_M_UP_3: 4346 flat devices **
XI0_0 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 D GTP GTP_0 WEI YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50WR_MUX_UP_M
XI0_1 BLA_ BLA BLB_ BLB WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66
+  WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76
+  WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86
+  WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96
+  WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI0_2 BLA_ BLA BLA__0 BLA__1 BLA__2 BLA_0 BLA_1 BLA_2 BLB_ BLB BLB__0 BLB__1
+  BLB__2 BLB_0 BLB_1 BLB_2 GTP_1 GTPSA Q YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD
+  rf2p_512x64_4_50RD_MUX_UP
XI1_1 BLA__0 BLA_0 BLB__0 BLB_0 WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI2_1 BLA__1 BLA_1 BLB__1 BLB_1 WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI3_1 BLA__2 BLA_2 BLB__2 BLB_2 MWLAL WLA0 MWLBL WLB0 WLA WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_FLMWG
.ENDS rf2p_512x64_4_50BCOL_M_UP_3
****
.SUBCKT rf2p_512x64_4_50WING_LEFT_32 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9
+  D_10 D_11 D_12 D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 D_21 D_22 D_23 D_24
+  D_25 D_26 D_27 D_28 D_29 D_30 GTP GTPSA_ GTP_0 GTP_1 Q Q_0 Q_1 Q_2 Q_3 Q_4
+  Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17 Q_18 Q_19 Q_20
+  Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28 Q_29 Q_30 WEI_ WLA WLA0 WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64
+  WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74
+  WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84
+  WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94
+  WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104
+  WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113
+  WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122
+  WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS
+  VDD
** rf2p_512x64_4_50WING_LEFT_32: 139072 flat devices **
XI0 D GTP GTPSA_ GTP_0 GTP_1 Q WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI1 D_0 GTP GTPSA_ GTP_0 GTP_1 Q_0 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI10 D_9 GTP GTPSA_ GTP_0 GTP_1 Q_9 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI11 D_10 GTP GTPSA_ GTP_0 GTP_1 Q_10 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_UP
XI12 D_11 GTP GTPSA_ GTP_0 GTP_1 Q_11 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_DN
XI13 D_12 GTP GTPSA_ GTP_0 GTP_1 Q_12 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_UP
XI14 D_13 GTP GTPSA_ GTP_0 GTP_1 Q_13 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_DN
XI15 D_14 GTP GTPSA_ GTP_0 GTP_1 WLA0 WLB0 Q_14 WEI_ WLA VSS WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64
+  WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74
+  WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84
+  WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94
+  WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104
+  WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113
+  WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122
+  WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS
+  VDD rf2p_512x64_4_50BCOL_M_UP_3
XI16 D_15 GTP GTPSA_ GTP_0 GTP_1 Q_15 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI17 D_16 GTP GTPSA_ GTP_0 GTP_1 Q_16 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI18 D_17 GTP GTPSA_ GTP_0 GTP_1 Q_17 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI19 D_18 GTP GTPSA_ GTP_0 GTP_1 Q_18 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI2 D_1 GTP GTPSA_ GTP_0 GTP_1 Q_1 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI20 D_19 GTP GTPSA_ GTP_0 GTP_1 Q_19 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI21 D_20 GTP GTPSA_ GTP_0 GTP_1 Q_20 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI22 D_21 GTP GTPSA_ GTP_0 GTP_1 Q_21 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI23 D_22 GTP GTPSA_ GTP_0 GTP_1 Q_22 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI24 D_23 GTP GTPSA_ GTP_0 GTP_1 Q_23 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI25 D_24 GTP GTPSA_ GTP_0 GTP_1 Q_24 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI26 D_25 GTP GTPSA_ GTP_0 GTP_1 Q_25 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI27 D_26 GTP GTPSA_ GTP_0 GTP_1 Q_26 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI28 D_27 GTP GTPSA_ GTP_0 GTP_1 Q_27 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI29 D_28 GTP GTPSA_ GTP_0 GTP_1 Q_28 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI3 D_2 GTP GTPSA_ GTP_0 GTP_1 Q_2 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI30 D_29 GTP GTPSA_ GTP_0 GTP_1 Q_29 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI31 D_30 GTP GTPSA_ GTP_0 GTP_1 Q_30 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI4 D_3 GTP GTPSA_ GTP_0 GTP_1 Q_3 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI5 D_4 GTP GTPSA_ GTP_0 GTP_1 Q_4 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI6 D_5 GTP GTPSA_ GTP_0 GTP_1 Q_5 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI7 D_6 GTP GTPSA_ GTP_0 GTP_1 Q_6 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI8 D_7 GTP GTPSA_ GTP_0 GTP_1 Q_7 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI9 D_8 GTP GTPSA_ GTP_0 GTP_1 Q_8 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
.ENDS rf2p_512x64_4_50WING_LEFT_32
****
.SUBCKT rf2p_512x64_4_50WD G00 G01 G1 G2 G3 GTP WL0 WL1 WLA0 WLA1 WLB0 WLB1
+  XP0 XP1 XP2 XP3 VSS VDD
** rf2p_512x64_4_50WD: 50 flat devices **
m1 WL1 WIN1 VDD VDD P L=0.18U W=9.52U
m10 GTPIN1 WL1 GTP VSS N L=0.18U W=0.43U
m11 GTPIN0 RSL0 GTP VDD P L=0.18U W=1.12U
m12 GTP WL0 GTPIN0 VSS N L=0.18U W=0.43U
m13 GTPIN1 WIN1 VSS VSS N L=0.36U W=0.22U
m14 GTPIN0 WIN0 VSS VSS N L=0.36U W=0.22U
m15 GTPIN GTP VDD VDD P L=0.18U W=0.62U
m16 GTPIN GTP VSS VSS N L=0.18U W=0.31U
m17 GTPBUF GTPIN VDD VDD P L=0.18U W=0.62U
m18 GTPBUF GTPIN VSS VSS N L=0.18U W=0.31U
m19 RSL1 GTPIN N56 VDD P L=0.18U W=0.42U
m2 WL1 WIN1 VSS VSS N L=0.18U W=4.22U
m20 N56 RSL1INV VDD VDD P L=0.18U W=0.42U
m21 RSL1 GTPBUF N55 VSS N L=0.18U W=0.42U
m22 N55 RSL1INV VSS VSS N L=0.18U W=0.42U
m23 RSL0 GTPIN N58 VDD P L=0.18U W=0.42U
m24 N58 RSL0INV VDD VDD P L=0.18U W=0.42U
m25 RSL0 GTPBUF N57 VSS N L=0.18U W=0.42U
m26 N57 RSL0INV VSS VSS N L=0.18U W=0.42U
m27 RSL1INV RSL1 VDD VDD P L=0.18U W=0.36U
m28 RSL1INV RSL1 VSS VSS N L=0.18U W=0.22U
m29 RSL0INV RSL0 VDD VDD P L=0.18U W=0.36U
m3 WL0 WIN0 VDD VDD P L=0.18U W=9.52U
m30 RSL0INV RSL0 VSS VSS N L=0.18U W=0.22U
m31 RS1 G3 VDD VDD P L=0.18U W=0.65U
m32 N61 G3 VSS VSS N L=0.18U W=0.65U
m33 RS1 G2 VDD VDD P L=0.18U W=0.65U
m34 N60 G2 N61 VSS N L=0.18U W=0.65U
m35 RS1 G1 VDD VDD P L=0.18U W=0.65U
m36 N59 G1 N60 VSS N L=0.18U W=0.65U
m37 RS1 G01 VDD VDD P L=0.18U W=0.65U
m38 RS1 G01 N59 VSS N L=0.18U W=0.65U
m39 RS0 G3 VDD VDD P L=0.18U W=0.65U
m4 WL0 WIN0 VSS VSS N L=0.18U W=4.22U
m40 N64 G3 VSS VSS N L=0.18U W=0.65U
m41 RS0 G2 VDD VDD P L=0.18U W=0.65U
m42 N63 G2 N64 VSS N L=0.18U W=0.65U
m43 RS0 G1 VDD VDD P L=0.18U W=0.65U
m44 N62 G1 N63 VSS N L=0.18U W=0.65U
m45 RS0 G00 VDD VDD P L=0.18U W=0.65U
m46 RS0 G00 N62 VSS N L=0.18U W=0.65U
m47 RS0 GTPBUF RSL0 VDD P L=0.18U W=0.68U
m48 RSL0 GTPIN RS0 VSS N L=0.18U W=0.68U
m49 RS1 GTPBUF RSL1 VDD P L=0.18U W=0.68U
m5 WIN0 GTPIN0 VDD VDD P L=0.18U W=4.18U
m50 RSL1 GTPIN RS1 VSS N L=0.18U W=0.68U
m6 WIN0 GTPIN0 VSS VSS N L=0.18U W=1.96U
m7 WIN1 GTPIN1 VDD VDD P L=0.18U W=4.18U
m8 WIN1 GTPIN1 VSS VSS N L=0.18U W=1.96U
m9 GTP RSL1 GTPIN1 VDD P L=0.18U W=1.12U
.ENDS rf2p_512x64_4_50WD
****
.SUBCKT rf2p_512x64_4_50WDV_LEFT_1 G1 G2 G3 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1
+  XP2 XP3 VSS VDD
** rf2p_512x64_4_50WDV_LEFT_1: 50 flat devices **
XI0 XP3 XP2 G1 G2 G3 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WD
.ENDS rf2p_512x64_4_50WDV_LEFT_1
****
.SUBCKT rf2p_512x64_4_50WDV_LEFT_0 G1 G2 G3 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1
+  XP2 XP3 VSS VDD
** rf2p_512x64_4_50WDV_LEFT_0: 50 flat devices **
XI0 XP1 XP0 G1 G2 G3 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WD
.ENDS rf2p_512x64_4_50WDV_LEFT_0
****
.SUBCKT rf2p_512x64_4_50MWDL GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
** rf2p_512x64_4_50MWDL: 7 flat devices **
m1 WLA0 WINB0 VDD VDD P L=0.18U W=12.37U
m2 WLA0 WINB0 VSS VSS N L=0.18U W=5.48U
m3 WINB0 N13 VDD VDD P L=0.18U W=4.18U
m4 WINB0 N13 VSS VSS N L=0.18U W=1.96U
m5 GTP VSS N13 VDD P L=0.18U W=1.2U
m6 GTP WLA0 N13 VSS N L=0.18U W=0.43U
m7 N13 WINB0 VSS VSS N L=0.36U W=0.22U
.ENDS rf2p_512x64_4_50MWDL
****
.SUBCKT rf2p_512x64_4_50WDSTACK_LEFT G1 G1_0 G1_1 G1_2 G1_3 G1_4 G1_5 G1_6
+  G1_7 G1_8 G1_9 G1_10 G1_11 G1_12 G1_13 G1_14 G1_15 G1_16 G1_17 G1_18 G1_19
+  G1_20 G1_21 G1_22 G1_23 G1_24 G1_25 G1_26 G1_27 G1_28 G1_29 G1_30 G1_31
+  G1_32 G1_33 G1_34 G1_35 G1_36 G1_37 G1_38 G1_39 G1_40 G1_41 G1_42 G1_43
+  G1_44 G1_45 G1_46 G1_47 G1_48 G1_49 G1_50 G1_51 G1_52 G1_53 G1_54 G1_55
+  G1_56 G1_57 G1_58 G1_59 G1_60 G1_61 G1_62 G2 G2_0 G2_1 G2_2 G2_3 G2_4 G2_5
+  G2_6 G2_7 G2_8 G2_9 G2_10 G2_11 G2_12 G2_13 G2_14 G2_15 G2_16 G2_17 G2_18
+  G2_19 G2_20 G2_21 G2_22 G2_23 G2_24 G2_25 G2_26 G2_27 G2_28 G2_29 G2_30
+  G2_31 G2_32 G2_33 G2_34 G2_35 G2_36 G2_37 G2_38 G2_39 G2_40 G2_41 G2_42
+  G2_43 G2_44 G2_45 G2_46 G2_47 G2_48 G2_49 G2_50 G2_51 G2_52 G2_53 G2_54
+  G2_55 G2_56 G2_57 G2_58 G2_59 G2_60 G2_61 G2_62 G3 G3_0 G3_1 G3_2 G3_3 G3_4
+  G3_5 G3_6 G3_7 G3_8 G3_9 G3_10 G3_11 G3_12 G3_13 G3_14 G3_15 G3_16 G3_17
+  G3_18 G3_19 G3_20 G3_21 G3_22 G3_23 G3_24 G3_25 G3_26 G3_27 G3_28 G3_29
+  G3_30 G3_31 G3_32 G3_33 G3_34 G3_35 G3_36 G3_37 G3_38 G3_39 G3_40 G3_41
+  G3_42 G3_43 G3_44 G3_45 G3_46 G3_47 G3_48 G3_49 G3_50 G3_51 G3_52 G3_53
+  G3_54 G3_55 G3_56 G3_57 G3_58 G3_59 G3_60 G3_61 G3_62 GTP WLA0 WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19
+  WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28
+  WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37
+  WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46
+  WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55
+  WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA1 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLB0 WLB0_0
+  WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10
+  WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19
+  WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28
+  WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37
+  WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46
+  WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55
+  WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB1 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 XP0 XP1 XP2
+  XP3 VSS VDD
** rf2p_512x64_4_50WDSTACK_LEFT: 3207 flat devices **
XI0 G1 G2 G3 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_0
XI1 G1_0 G2_0 G3_0 GTP WLA0_0 WLA1_0 WLB0_0 WLB1_0 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_1
XI10 G1_9 G2_9 G3_9 GTP WLA0_9 WLA1_9 WLB0_9 WLB1_9 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_0
XI11 G1_10 G2_10 G3_10 GTP WLA0_10 WLA1_10 WLB0_10 WLB1_10 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI12 G1_11 G2_11 G3_11 GTP WLA0_11 WLA1_11 WLB0_11 WLB1_11 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI13 G1_12 G2_12 G3_12 GTP WLA0_12 WLA1_12 WLB0_12 WLB1_12 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI14 G1_13 G2_13 G3_13 GTP WLA0_13 WLA1_13 WLB0_13 WLB1_13 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI15 G1_14 G2_14 G3_14 GTP WLA0_14 WLA1_14 WLB0_14 WLB1_14 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI17 G1_15 G2_15 G3_15 GTP WLA0_15 WLA1_15 WLB0_15 WLB1_15 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI18 G1_16 G2_16 G3_16 GTP WLA0_16 WLA1_16 WLB0_16 WLB1_16 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI19 G1_17 G2_17 G3_17 GTP WLA0_17 WLA1_17 WLB0_17 WLB1_17 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI2 G1_1 G2_1 G3_1 GTP WLA0_1 WLA1_1 WLB0_1 WLB1_1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_0
XI20 G1_18 G2_18 G3_18 GTP WLA0_18 WLA1_18 WLB0_18 WLB1_18 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI21 G1_19 G2_19 G3_19 GTP WLA0_19 WLA1_19 WLB0_19 WLB1_19 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI22 G1_20 G2_20 G3_20 GTP WLA0_20 WLA1_20 WLB0_20 WLB1_20 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI23 G1_21 G2_21 G3_21 GTP WLA0_21 WLA1_21 WLB0_21 WLB1_21 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI24 G1_22 G2_22 G3_22 GTP WLA0_22 WLA1_22 WLB0_22 WLB1_22 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI25 G1_23 G2_23 G3_23 GTP WLA0_23 WLA1_23 WLB0_23 WLB1_23 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI26 G1_24 G2_24 G3_24 GTP WLA0_24 WLA1_24 WLB0_24 WLB1_24 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI27 G1_25 G2_25 G3_25 GTP WLA0_25 WLA1_25 WLB0_25 WLB1_25 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI28 G1_26 G2_26 G3_26 GTP WLA0_26 WLA1_26 WLB0_26 WLB1_26 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI29 G1_27 G2_27 G3_27 GTP WLA0_27 WLA1_27 WLB0_27 WLB1_27 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI3 G1_2 G2_2 G3_2 GTP WLA0_2 WLA1_2 WLB0_2 WLB1_2 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_1
XI30 G1_28 G2_28 G3_28 GTP WLA0_28 WLA1_28 WLB0_28 WLB1_28 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI31 G1_29 G2_29 G3_29 GTP WLA0_29 WLA1_29 WLB0_29 WLB1_29 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI32 G1_30 G2_30 G3_30 GTP WLA0_30 WLA1_30 WLB0_30 WLB1_30 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI33 GTP WLA0_31 WLA1_63 WLB0_31 WLB1_63 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50MWDL
XI34 G1_31 G2_31 G3_31 GTP WLA0_32 WLA1_31 WLB0_32 WLB1_31 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI35 G1_32 G2_32 G3_32 GTP WLA0_33 WLA1_32 WLB0_33 WLB1_32 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI36 G1_33 G2_33 G3_33 GTP WLA0_34 WLA1_33 WLB0_34 WLB1_33 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI37 G1_34 G2_34 G3_34 GTP WLA0_35 WLA1_34 WLB0_35 WLB1_34 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI38 G1_35 G2_35 G3_35 GTP WLA0_36 WLA1_35 WLB0_36 WLB1_35 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI39 G1_36 G2_36 G3_36 GTP WLA0_37 WLA1_36 WLB0_37 WLB1_36 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI4 G1_3 G2_3 G3_3 GTP WLA0_3 WLA1_3 WLB0_3 WLB1_3 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_0
XI40 G1_37 G2_37 G3_37 GTP WLA0_38 WLA1_37 WLB0_38 WLB1_37 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI41 G1_38 G2_38 G3_38 GTP WLA0_39 WLA1_38 WLB0_39 WLB1_38 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI42 G1_39 G2_39 G3_39 GTP WLA0_40 WLA1_39 WLB0_40 WLB1_39 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI43 G1_40 G2_40 G3_40 GTP WLA0_41 WLA1_40 WLB0_41 WLB1_40 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI44 G1_41 G2_41 G3_41 GTP WLA0_42 WLA1_41 WLB0_42 WLB1_41 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI45 G1_42 G2_42 G3_42 GTP WLA0_43 WLA1_42 WLB0_43 WLB1_42 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI46 G1_43 G2_43 G3_43 GTP WLA0_44 WLA1_43 WLB0_44 WLB1_43 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI47 G1_44 G2_44 G3_44 GTP WLA0_45 WLA1_44 WLB0_45 WLB1_44 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI48 G1_45 G2_45 G3_45 GTP WLA0_46 WLA1_45 WLB0_46 WLB1_45 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI5 G1_4 G2_4 G3_4 GTP WLA0_4 WLA1_4 WLB0_4 WLB1_4 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_1
XI50 G1_46 G2_46 G3_46 GTP WLA0_47 WLA1_46 WLB0_47 WLB1_46 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI51 G1_47 G2_47 G3_47 GTP WLA0_48 WLA1_47 WLB0_48 WLB1_47 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI52 G1_48 G2_48 G3_48 GTP WLA0_49 WLA1_48 WLB0_49 WLB1_48 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI53 G1_49 G2_49 G3_49 GTP WLA0_50 WLA1_49 WLB0_50 WLB1_49 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI54 G1_50 G2_50 G3_50 GTP WLA0_51 WLA1_50 WLB0_51 WLB1_50 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI55 G1_51 G2_51 G3_51 GTP WLA0_52 WLA1_51 WLB0_52 WLB1_51 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI56 G1_52 G2_52 G3_52 GTP WLA0_53 WLA1_52 WLB0_53 WLB1_52 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI57 G1_53 G2_53 G3_53 GTP WLA0_54 WLA1_53 WLB0_54 WLB1_53 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI58 G1_54 G2_54 G3_54 GTP WLA0_55 WLA1_54 WLB0_55 WLB1_54 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI59 G1_55 G2_55 G3_55 GTP WLA0_56 WLA1_55 WLB0_56 WLB1_55 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI6 G1_5 G2_5 G3_5 GTP WLA0_5 WLA1_5 WLB0_5 WLB1_5 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_0
XI60 G1_56 G2_56 G3_56 GTP WLA0_57 WLA1_56 WLB0_57 WLB1_56 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI61 G1_57 G2_57 G3_57 GTP WLA0_58 WLA1_57 WLB0_58 WLB1_57 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI62 G1_58 G2_58 G3_58 GTP WLA0_59 WLA1_58 WLB0_59 WLB1_58 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI63 G1_59 G2_59 G3_59 GTP WLA0_60 WLA1_59 WLB0_60 WLB1_59 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI64 G1_60 G2_60 G3_60 GTP WLA0_61 WLA1_60 WLB0_61 WLB1_60 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI65 G1_61 G2_61 G3_61 GTP WLA0_62 WLA1_61 WLB0_62 WLB1_61 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_0
XI66 G1_62 G2_62 G3_62 GTP WLA0_63 WLA1_62 WLB0_63 WLB1_62 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_LEFT_1
XI7 G1_6 G2_6 G3_6 GTP WLA0_6 WLA1_6 WLB0_6 WLB1_6 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_1
XI8 G1_7 G2_7 G3_7 GTP WLA0_7 WLA1_7 WLB0_7 WLB1_7 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_0
XI9 G1_8 G2_8 G3_8 GTP WLA0_8 WLA1_8 WLB0_8 WLB1_8 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_LEFT_1
.ENDS rf2p_512x64_4_50WDSTACK_LEFT
****
.SUBCKT rf2p_512x64_4_50WDV_RIGHT_1 G1 G2 G3 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1
+  XP2 XP3 VSS VDD
** rf2p_512x64_4_50WDV_RIGHT_1: 50 flat devices **
XI0 XP2 XP3 G1 G2 G3 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WD
.ENDS rf2p_512x64_4_50WDV_RIGHT_1
****
.SUBCKT rf2p_512x64_4_50WDV_RIGHT_0 G1 G2 G3 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1
+  XP2 XP3 VSS VDD
** rf2p_512x64_4_50WDV_RIGHT_0: 50 flat devices **
XI0 XP0 XP1 G1 G2 G3 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WD
.ENDS rf2p_512x64_4_50WDV_RIGHT_0
****
.SUBCKT rf2p_512x64_4_50MWDR GTP MBLA MBLB WLA0 WLALATE WLB0 WLBLATE XP0 XP1
+  XP2 XP3 VSS VDD
** rf2p_512x64_4_50MWDR: 7 flat devices **
m1 WLB0 WINB0 VDD VDD P L=0.18U W=12.37U
m2 WLB0 WINB0 VSS VSS N L=0.18U W=5.48U
m3 WINB0 N15 VDD VDD P L=0.18U W=4.18U
m4 WINB0 N15 VSS VSS N L=0.18U W=1.96U
m5 N15 VSS GTP VDD P L=0.18U W=1.2U
m6 N15 WLB0 GTP VSS N L=0.18U W=0.43U
m7 N15 WINB0 VSS VSS N L=0.36U W=0.22U
.ENDS rf2p_512x64_4_50MWDR
****
.SUBCKT rf2p_512x64_4_50WDSTACK_RIGHT G1 G1_0 G1_1 G1_2 G1_3 G1_4 G1_5 G1_6
+  G1_7 G1_8 G1_9 G1_10 G1_11 G1_12 G1_13 G1_14 G1_15 G1_16 G1_17 G1_18 G1_19
+  G1_20 G1_21 G1_22 G1_23 G1_24 G1_25 G1_26 G1_27 G1_28 G1_29 G1_30 G1_31
+  G1_32 G1_33 G1_34 G1_35 G1_36 G1_37 G1_38 G1_39 G1_40 G1_41 G1_42 G1_43
+  G1_44 G1_45 G1_46 G1_47 G1_48 G1_49 G1_50 G1_51 G1_52 G1_53 G1_54 G1_55
+  G1_56 G1_57 G1_58 G1_59 G1_60 G1_61 G1_62 G2 G2_0 G2_1 G2_2 G2_3 G2_4 G2_5
+  G2_6 G2_7 G2_8 G2_9 G2_10 G2_11 G2_12 G2_13 G2_14 G2_15 G2_16 G2_17 G2_18
+  G2_19 G2_20 G2_21 G2_22 G2_23 G2_24 G2_25 G2_26 G2_27 G2_28 G2_29 G2_30
+  G2_31 G2_32 G2_33 G2_34 G2_35 G2_36 G2_37 G2_38 G2_39 G2_40 G2_41 G2_42
+  G2_43 G2_44 G2_45 G2_46 G2_47 G2_48 G2_49 G2_50 G2_51 G2_52 G2_53 G2_54
+  G2_55 G2_56 G2_57 G2_58 G2_59 G2_60 G2_61 G2_62 G3 G3_0 G3_1 G3_2 G3_3 G3_4
+  G3_5 G3_6 G3_7 G3_8 G3_9 G3_10 G3_11 G3_12 G3_13 G3_14 G3_15 G3_16 G3_17
+  G3_18 G3_19 G3_20 G3_21 G3_22 G3_23 G3_24 G3_25 G3_26 G3_27 G3_28 G3_29
+  G3_30 G3_31 G3_32 G3_33 G3_34 G3_35 G3_36 G3_37 G3_38 G3_39 G3_40 G3_41
+  G3_42 G3_43 G3_44 G3_45 G3_46 G3_47 G3_48 G3_49 G3_50 G3_51 G3_52 G3_53
+  G3_54 G3_55 G3_56 G3_57 G3_58 G3_59 G3_60 G3_61 G3_62 GTP MBLA MBLB WLA0
+  WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9
+  WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18
+  WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27
+  WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36
+  WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45
+  WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54
+  WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63
+  WLA1 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36
+  WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45
+  WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54
+  WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLALATE
+  WLB0 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36
+  WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45
+  WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54
+  WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63
+  WLB1 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9
+  WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18
+  WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27
+  WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36
+  WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45
+  WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54
+  WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLBLATE XP0
+  XP1 XP2 XP3 VSS VDD
** rf2p_512x64_4_50WDSTACK_RIGHT: 3207 flat devices **
XI0 G1 G2 G3 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_0
XI1 G1_0 G2_0 G3_0 GTP WLA0_0 WLA1_0 WLB0_0 WLB1_0 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_1
XI10 G1_9 G2_9 G3_9 GTP WLA0_9 WLA1_9 WLB0_9 WLB1_9 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_0
XI11 G1_10 G2_10 G3_10 GTP WLA0_10 WLA1_10 WLB0_10 WLB1_10 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI12 G1_11 G2_11 G3_11 GTP WLA0_11 WLA1_11 WLB0_11 WLB1_11 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI13 G1_12 G2_12 G3_12 GTP WLA0_12 WLA1_12 WLB0_12 WLB1_12 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI14 G1_13 G2_13 G3_13 GTP WLA0_13 WLA1_13 WLB0_13 WLB1_13 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI15 G1_14 G2_14 G3_14 GTP WLA0_14 WLA1_14 WLB0_14 WLB1_14 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI17 G1_15 G2_15 G3_15 GTP WLA0_15 WLA1_15 WLB0_15 WLB1_15 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI18 G1_16 G2_16 G3_16 GTP WLA0_16 WLA1_16 WLB0_16 WLB1_16 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI19 G1_17 G2_17 G3_17 GTP WLA0_17 WLA1_17 WLB0_17 WLB1_17 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI2 G1_1 G2_1 G3_1 GTP WLA0_1 WLA1_1 WLB0_1 WLB1_1 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_0
XI20 G1_18 G2_18 G3_18 GTP WLA0_18 WLA1_18 WLB0_18 WLB1_18 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI21 G1_19 G2_19 G3_19 GTP WLA0_19 WLA1_19 WLB0_19 WLB1_19 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI22 G1_20 G2_20 G3_20 GTP WLA0_20 WLA1_20 WLB0_20 WLB1_20 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI23 G1_21 G2_21 G3_21 GTP WLA0_21 WLA1_21 WLB0_21 WLB1_21 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI24 G1_22 G2_22 G3_22 GTP WLA0_22 WLA1_22 WLB0_22 WLB1_22 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI25 G1_23 G2_23 G3_23 GTP WLA0_23 WLA1_23 WLB0_23 WLB1_23 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI26 G1_24 G2_24 G3_24 GTP WLA0_24 WLA1_24 WLB0_24 WLB1_24 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI27 G1_25 G2_25 G3_25 GTP WLA0_25 WLA1_25 WLB0_25 WLB1_25 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI28 G1_26 G2_26 G3_26 GTP WLA0_26 WLA1_26 WLB0_26 WLB1_26 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI29 G1_27 G2_27 G3_27 GTP WLA0_27 WLA1_27 WLB0_27 WLB1_27 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI3 G1_2 G2_2 G3_2 GTP WLA0_2 WLA1_2 WLB0_2 WLB1_2 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_1
XI30 G1_28 G2_28 G3_28 GTP WLA0_28 WLA1_28 WLB0_28 WLB1_28 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI31 G1_29 G2_29 G3_29 GTP WLA0_29 WLA1_29 WLB0_29 WLB1_29 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI32 G1_30 G2_30 G3_30 GTP WLA0_30 WLA1_30 WLB0_30 WLB1_30 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI33 GTP MBLA MBLB WLA0_31 WLALATE WLB0_31 WLBLATE XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50MWDR
XI34 G1_31 G2_31 G3_31 GTP WLA0_32 WLA1_31 WLB0_32 WLB1_31 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI35 G1_32 G2_32 G3_32 GTP WLA0_33 WLA1_32 WLB0_33 WLB1_32 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI36 G1_33 G2_33 G3_33 GTP WLA0_34 WLA1_33 WLB0_34 WLB1_33 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI37 G1_34 G2_34 G3_34 GTP WLA0_35 WLA1_34 WLB0_35 WLB1_34 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI38 G1_35 G2_35 G3_35 GTP WLA0_36 WLA1_35 WLB0_36 WLB1_35 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI39 G1_36 G2_36 G3_36 GTP WLA0_37 WLA1_36 WLB0_37 WLB1_36 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI4 G1_3 G2_3 G3_3 GTP WLA0_3 WLA1_3 WLB0_3 WLB1_3 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_0
XI40 G1_37 G2_37 G3_37 GTP WLA0_38 WLA1_37 WLB0_38 WLB1_37 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI41 G1_38 G2_38 G3_38 GTP WLA0_39 WLA1_38 WLB0_39 WLB1_38 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI42 G1_39 G2_39 G3_39 GTP WLA0_40 WLA1_39 WLB0_40 WLB1_39 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI43 G1_40 G2_40 G3_40 GTP WLA0_41 WLA1_40 WLB0_41 WLB1_40 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI44 G1_41 G2_41 G3_41 GTP WLA0_42 WLA1_41 WLB0_42 WLB1_41 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI45 G1_42 G2_42 G3_42 GTP WLA0_43 WLA1_42 WLB0_43 WLB1_42 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI46 G1_43 G2_43 G3_43 GTP WLA0_44 WLA1_43 WLB0_44 WLB1_43 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI47 G1_44 G2_44 G3_44 GTP WLA0_45 WLA1_44 WLB0_45 WLB1_44 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI48 G1_45 G2_45 G3_45 GTP WLA0_46 WLA1_45 WLB0_46 WLB1_45 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI5 G1_4 G2_4 G3_4 GTP WLA0_4 WLA1_4 WLB0_4 WLB1_4 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_1
XI50 G1_46 G2_46 G3_46 GTP WLA0_47 WLA1_46 WLB0_47 WLB1_46 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI51 G1_47 G2_47 G3_47 GTP WLA0_48 WLA1_47 WLB0_48 WLB1_47 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI52 G1_48 G2_48 G3_48 GTP WLA0_49 WLA1_48 WLB0_49 WLB1_48 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI53 G1_49 G2_49 G3_49 GTP WLA0_50 WLA1_49 WLB0_50 WLB1_49 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI54 G1_50 G2_50 G3_50 GTP WLA0_51 WLA1_50 WLB0_51 WLB1_50 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI55 G1_51 G2_51 G3_51 GTP WLA0_52 WLA1_51 WLB0_52 WLB1_51 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI56 G1_52 G2_52 G3_52 GTP WLA0_53 WLA1_52 WLB0_53 WLB1_52 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI57 G1_53 G2_53 G3_53 GTP WLA0_54 WLA1_53 WLB0_54 WLB1_53 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI58 G1_54 G2_54 G3_54 GTP WLA0_55 WLA1_54 WLB0_55 WLB1_54 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI59 G1_55 G2_55 G3_55 GTP WLA0_56 WLA1_55 WLB0_56 WLB1_55 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI6 G1_5 G2_5 G3_5 GTP WLA0_5 WLA1_5 WLB0_5 WLB1_5 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_0
XI60 G1_56 G2_56 G3_56 GTP WLA0_57 WLA1_56 WLB0_57 WLB1_56 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI61 G1_57 G2_57 G3_57 GTP WLA0_58 WLA1_57 WLB0_58 WLB1_57 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI62 G1_58 G2_58 G3_58 GTP WLA0_59 WLA1_58 WLB0_59 WLB1_58 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI63 G1_59 G2_59 G3_59 GTP WLA0_60 WLA1_59 WLB0_60 WLB1_59 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI64 G1_60 G2_60 G3_60 GTP WLA0_61 WLA1_60 WLB0_61 WLB1_60 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI65 G1_61 G2_61 G3_61 GTP WLA0_62 WLA1_61 WLB0_62 WLB1_61 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_0
XI66 G1_62 G2_62 G3_62 GTP WLA0_63 WLA1_62 WLB0_63 WLB1_62 XP0 XP1 XP2 XP3 VSS
+  VDD rf2p_512x64_4_50WDV_RIGHT_1
XI7 G1_6 G2_6 G3_6 GTP WLA0_6 WLA1_6 WLB0_6 WLB1_6 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_1
XI8 G1_7 G2_7 G3_7 GTP WLA0_7 WLA1_7 WLB0_7 WLB1_7 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_0
XI9 G1_8 G2_8 G3_8 GTP WLA0_8 WLA1_8 WLB0_8 WLB1_8 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDV_RIGHT_1
.ENDS rf2p_512x64_4_50WDSTACK_RIGHT
****
.SUBCKT rf2p_512x64_4_50CTRL_MID G2 G3 GTP GTP_0 MBLA MBLB STUBG2 STUBG3 WLA0
+  WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9
+  WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18
+  WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27
+  WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36
+  WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45
+  WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54
+  WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63
+  WLA1 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36
+  WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45
+  WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54
+  WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63
+  WLALATE WLB0 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8
+  WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17
+  WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26
+  WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35
+  WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44
+  WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53
+  WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62
+  WLB0_63 WLB1 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8
+  WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17
+  WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26
+  WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35
+  WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44
+  WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53
+  WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62
+  WLB1_63 WLBLATE XP0 XP0_0 XP1 XP1_0 XP2 XP2_0 XP3 XP3_0 XPA0 XPA0_0 XPA0_1
+  XPA0_2 XPA0_3 XPA1 XPA1_0 XPA1_1 XPB0 XPB0_0 XPB0_1 XPB1 XPB1_0 XPB1_1
+  XPB1_2 XPB1_3 VSS VDD
** rf2p_512x64_4_50CTRL_MID: 6414 flat devices **
XI0 XPB1 XPB1 XPB0 XPB0 XPB1_0 XPB1_0 XPB0_0 XPB0_0 XPB1 XPB1 XPB0 XPB0 XPB1_0
+  XPB1_0 XPB0_0 XPB0_0 XPB1 XPB1 XPB0 XPB0 XPB1_0 XPB1_0 XPB0_0 XPB0_0 XPB1
+  XPB1 XPB0 XPB0 XPB1_0 XPB1_0 XPB0_0 XPB0_0 XPB1 XPB1 XPB0 XPB0 XPB1_0
+  XPB1_0 XPB0_0 XPB0_0 XPB1 XPB1 XPB0 XPB0 XPB1_0 XPB1_0 XPB0_0 XPB0_0 XPB1
+  XPB1 XPB0 XPB0 XPB1_0 XPB1_0 XPB0_0 XPB0_0 XPB1 XPB1 XPB0 XPB0 XPB1_0
+  XPB1_0 XPB0_0 XPB0_0 XPB1_1 XPB1_1 XPB1_1 XPB1_1 XPB1_1 XPB1_1 XPB1_1
+  XPB1_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB1_2
+  XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 STUBG2 STUBG2 STUBG2
+  STUBG2 STUBG2 STUBG2 STUBG2 STUBG2 XPB1_1 XPB1_1 XPB1_1 XPB1_1 XPB1_1
+  XPB1_1 XPB1_1 XPB1_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1 XPB0_1
+  XPB0_1 XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 XPB1_2 STUBG2
+  STUBG2 STUBG2 STUBG2 STUBG2 STUBG2 STUBG2 STUBG2 XPB1_3 XPB1_3 XPB1_3
+  XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3
+  XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3
+  XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 XPB1_3 STUBG3
+  STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3
+  STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3
+  STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3 STUBG3
+  STUBG3 GTP WLA1 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7
+  WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16
+  WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25
+  WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA0_31 WLA1_31 WLA1_32 WLA1_33
+  WLA1_34 WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42
+  WLA1_43 WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51
+  WLA1_52 WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60
+  WLA1_61 WLA1_62 WLA0 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_32 WLA0_33 WLA0_34
+  WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43
+  WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52
+  WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61
+  WLA0_62 WLA0_63 WLA1_63 WLB1 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5
+  WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15
+  WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24
+  WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB0_31 WLB1_31 WLB1_32
+  WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41
+  WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50
+  WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59
+  WLB1_60 WLB1_61 WLB1_62 WLB0 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5
+  WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_32 WLB0_33 WLB0_34
+  WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43
+  WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52
+  WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61
+  WLB0_62 WLB0_63 WLB1_63 XP0 XP1 XP2 XP3 VSS VDD
+  rf2p_512x64_4_50WDSTACK_LEFT
XI2 XPA0_3 XPA0_3 XPA1_1 XPA1_1 XPA0_2 XPA0_2 XPA1_0 XPA1_0 XPA0_3 XPA0_3
+  XPA1_1 XPA1_1 XPA0_2 XPA0_2 XPA1_0 XPA1_0 XPA0_3 XPA0_3 XPA1_1 XPA1_1
+  XPA0_2 XPA0_2 XPA1_0 XPA1_0 XPA0_3 XPA0_3 XPA1_1 XPA1_1 XPA0_2 XPA0_2
+  XPA1_0 XPA1_0 XPA0_3 XPA0_3 XPA1_1 XPA1_1 XPA0_2 XPA0_2 XPA1_0 XPA1_0
+  XPA0_3 XPA0_3 XPA1_1 XPA1_1 XPA0_2 XPA0_2 XPA1_0 XPA1_0 XPA0_3 XPA0_3
+  XPA1_1 XPA1_1 XPA0_2 XPA0_2 XPA1_0 XPA1_0 XPA0_3 XPA0_3 XPA1_1 XPA1_1
+  XPA0_2 XPA0_2 XPA1_0 XPA1_0 XPA0_1 XPA0_1 XPA0_1 XPA0_1 XPA0_1 XPA0_1
+  XPA0_1 XPA0_1 XPA1 XPA1 XPA1 XPA1 XPA1 XPA1 XPA1 XPA1 XPA0_0 XPA0_0 XPA0_0
+  XPA0_0 XPA0_0 XPA0_0 XPA0_0 XPA0_0 G2 G2 G2 G2 G2 G2 G2 G2 XPA0_1 XPA0_1
+  XPA0_1 XPA0_1 XPA0_1 XPA0_1 XPA0_1 XPA0_1 XPA1 XPA1 XPA1 XPA1 XPA1 XPA1
+  XPA1 XPA1 XPA0_0 XPA0_0 XPA0_0 XPA0_0 XPA0_0 XPA0_0 XPA0_0 XPA0_0 G2 G2 G2
+  G2 G2 G2 G2 G2 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0
+  XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0 XPA0
+  XPA0 XPA0 XPA0 XPA0 XPA0 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3
+  G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 G3 GTP_0 MBLA MBLB WLA0 WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19
+  WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28
+  WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37
+  WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46
+  WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55
+  WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA1 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLALATE WLB0 WLB0_0
+  WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10
+  WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19
+  WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28
+  WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37
+  WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46
+  WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55
+  WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB1 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLBLATE XP0_0 XP1_0
+  XP2_0 XP3_0 VSS VDD rf2p_512x64_4_50WDSTACK_RIGHT
.ENDS rf2p_512x64_4_50CTRL_MID
****
.SUBCKT rf2p_512x64_4_50HYP24 AGTP AY0 AY1 CLK G2 G3 GTP GTPIO_WEI INOUT0
+  INOUT1 INOUT2 XP0 XP1 XP2 XP3 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50HYP24: 58 flat devices **
d29 VSS AY1 DN 0.3364P 2.32U
d58 VSS AY0 DN 0.3364P 2.32U
m1 APY1-APN1 APY1-GTPN APY1-AIND1 VSS N L=0.18U W=2.33U
m10 N47 YP3 VDD VDD P L=0.18U W=0.42U
m11 APY1-APN1 AGTP N46 VSS N L=0.18U W=0.42U
m12 N46 YP3 VSS VSS N L=0.18U W=0.42U
m13 YP3 APY1-APN1 VDD VDD P L=0.18U W=10.74U
m14 YP3 APY1-APN1 VSS VSS N L=0.18U W=4.54U
m15 APY1-APN0 APY1-GTPN APY1-APND0 VSS N L=0.18U W=2.33U
m16 APY1-APN0 AGTP APY1-APND0 VDD P L=0.18U W=2.79U
m17 APY1-APND0 N20 VDD VDD P L=0.18U W=4.34U
m18 N48 N20 VSS VSS N L=0.18U W=4.07U
m19 APY1-APND0 AY1 VDD VDD P L=0.18U W=4.34U
m2 APY1-APN1 AGTP APY1-AIND1 VDD P L=0.18U W=2.79U
m20 APY1-APND0 AY1 N48 VSS N L=0.18U W=4.07U
m21 APY1-APN0 APY1-GTPN N50 VDD P L=0.18U W=0.42U
m22 N50 YP2 VDD VDD P L=0.18U W=0.42U
m23 APY1-APN0 AGTP N49 VSS N L=0.18U W=0.42U
m24 N49 YP2 VSS VSS N L=0.18U W=0.42U
m25 YP2 APY1-APN0 VDD VDD P L=0.18U W=10.74U
m26 YP2 APY1-APN0 VSS VSS N L=0.18U W=4.54U
m27 N23 AY1 VDD VDD P L=0.18U W=3.65U
m28 N23 AY1 VSS VSS N L=0.18U W=1.71U
m3 APY1-GTPN AGTP VDD VDD P L=0.18U W=1.41U
m30 APY0-APN1 APY0-GTPN APY0-AIND1 VSS N L=0.18U W=2.33U
m31 APY0-APN1 AGTP APY0-AIND1 VDD P L=0.18U W=2.79U
m32 APY0-GTPN AGTP VDD VDD P L=0.18U W=1.41U
m33 APY0-GTPN AGTP VSS VSS N L=0.18U W=0.66U
m34 APY0-AIND1 N23 VDD VDD P L=0.18U W=4.34U
m35 N73 N23 VSS VSS N L=0.18U W=4.07U
m36 APY0-AIND1 N20 VDD VDD P L=0.18U W=4.34U
m37 APY0-AIND1 N20 N73 VSS N L=0.18U W=4.07U
m38 APY0-APN1 APY0-GTPN N75 VDD P L=0.18U W=0.42U
m39 N75 YP0 VDD VDD P L=0.18U W=0.42U
m4 APY1-GTPN AGTP VSS VSS N L=0.18U W=0.66U
m40 APY0-APN1 AGTP N74 VSS N L=0.18U W=0.42U
m41 N74 YP0 VSS VSS N L=0.18U W=0.42U
m42 YP0 APY0-APN1 VDD VDD P L=0.18U W=10.74U
m43 YP0 APY0-APN1 VSS VSS N L=0.18U W=4.54U
m44 APY0-APN0 APY0-GTPN APY0-APND0 VSS N L=0.18U W=2.33U
m45 APY0-APN0 AGTP APY0-APND0 VDD P L=0.18U W=2.79U
m46 APY0-APND0 AY0 VDD VDD P L=0.18U W=4.34U
m47 N76 AY0 VSS VSS N L=0.18U W=4.07U
m48 APY0-APND0 N23 VDD VDD P L=0.18U W=4.34U
m49 APY0-APND0 N23 N76 VSS N L=0.18U W=4.07U
m5 APY1-AIND1 AY1 VDD VDD P L=0.18U W=4.34U
m50 APY0-APN0 APY0-GTPN N78 VDD P L=0.18U W=0.42U
m51 N78 YP1 VDD VDD P L=0.18U W=0.42U
m52 APY0-APN0 AGTP N77 VSS N L=0.18U W=0.42U
m53 N77 YP1 VSS VSS N L=0.18U W=0.42U
m54 YP1 APY0-APN0 VDD VDD P L=0.18U W=10.74U
m55 YP1 APY0-APN0 VSS VSS N L=0.18U W=4.54U
m56 N20 AY0 VDD VDD P L=0.18U W=3.65U
m57 N20 AY0 VSS VSS N L=0.18U W=1.71U
m6 N45 AY1 VSS VSS N L=0.18U W=4.07U
m7 APY1-AIND1 AY0 VDD VDD P L=0.18U W=4.34U
m8 APY1-AIND1 AY0 N45 VSS N L=0.18U W=4.07U
m9 APY1-APN1 APY1-GTPN N47 VDD P L=0.18U W=0.42U
.ENDS rf2p_512x64_4_50HYP24
****
.SUBCKT rf2p_512x64_4_50CTRLSAL2 AGTP CEN CLK GTP GTPIO_WEI TMS YP0 YP1 YP2
+  YP3 VSS VDD
** rf2p_512x64_4_50CTRLSAL2: 43 flat devices **
d32 VSS CEN DN 0.3364P 2.32U
d33 VSS CLK DN 0.3364P 2.32U
d34 VSS TMS DN 0.3364P 2.32U
m1 GTP GTPN VDD VDD P L=0.18U W=50U
m10 GTCLK GTPNMIR VDD VDD P L=0.18U W=0.42U
m11 N55 GTPNMIR N56 VSS N L=0.18U W=0.42U
m12 GTCLK GTPIO_WEI VDD VDD P L=0.18U W=0.42U
m13 N54 GTPIO_WEI N55 VSS N L=0.18U W=0.42U
m14 GTCLK CEL VDD VDD P L=0.18U W=0.42U
m15 GTCLK CEL N54 VSS N L=0.18U W=0.42U
m16 CENMML CLKN N58 VDD P L=0.18U W=0.22U
m17 N58 CEL VDD VDD P L=0.18U W=0.22U
m18 CENMML CLK N57 VSS N L=0.18U W=0.22U
m19 N57 CEL VSS VSS N L=0.18U W=0.22U
m2 GTP GTPN VSS VSS N L=0.18U W=22U
m20 CEL CENMML VDD VDD P L=0.18U W=1U
m21 CEL CENMML VSS VSS N L=0.18U W=0.47U
m22 CLKN CLK VDD VDD P L=0.18U W=0.53U
m23 CLKN CLK VSS VSS N L=0.18U W=0.25U
m24 N38 CLKN VSS VSS N L=0.18U W=0.53U
m25 N40 CLK VDD VDD P L=0.18U W=1.1U
m26 CENMML N42 N43 VDD P L=0.18U W=1.1U
m27 CENMML N42 N38 VSS N L=0.18U W=0.53U
m28 N43 TMS N40 VDD P L=0.18U W=1.1U
m29 CENMML TMS N38 VSS N L=0.18U W=0.53U
m3 GTPN GTPKEEP VDD VDD P L=0.18U W=0.42U
m30 N42 CEN VDD VDD P L=0.18U W=0.45U
m31 N42 CEN VSS VSS N L=0.18U W=0.22U
m35 N21 CLK VDD VDD P L=0.18U W=20U
m36 N21 CLK VSS VSS N L=0.18U W=10U
m37 GTPN NODE1 N21 VSS N L=0.18U W=10U
m38 GTPNMIR GTP VDD VDD P L=0.18U W=0.8U
m39 GTPNMIR GTP VSS VSS N L=0.18U W=0.42U
m4 GTPN GTPKEEP VSS VSS N L=0.18U W=0.42U
m40 AGTP GTPN VDD VDD P L=0.18U W=3.7U
m41 AGTP GTPN VSS VSS N L=0.18U W=1.24U
m42 NODE1 GTCLK VDD VDD P L=0.18U W=1.2U
m43 NODE1 GTCLK VSS VSS N L=0.22U W=0.42U
m5 GTPKEEP GTPN VDD VDD P L=0.18U W=0.22U
m6 GTPKEEP GTPN VSS VSS N L=0.18U W=0.22U
m7 GTPN GTPIO_WEI VDD VDD P L=0.18U W=15.02U
m8 GTCLK N21 VDD VDD P L=0.18U W=0.42U
m9 N56 N21 VSS VSS N L=0.18U W=0.42U
.ENDS rf2p_512x64_4_50CTRLSAL2
****
.SUBCKT rf2p_512x64_4_50HXP12 AGTP AX0 CLK GTP GTPIO_WEI XPA0 XPA1 XPB0 XPB1
+  YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50HXP12: 15 flat devices **
d3 VSS AX0 DN 0.3364P 2.32U
m1 N15 AX0 VDD VDD P L=0.18U W=0.85U
m10 AP0-AIND0 VDD VDD VDD P L=0.18U W=1.3U
m11 N31 VDD VSS VSS N L=0.18U W=1.3U
m12 AP0-AIND0 AX0 VDD VDD P L=0.18U W=1.3U
m13 AP0-AIND0 AX0 N31 VSS N L=0.18U W=1.3U
m14 XPA1 AP0-AIND0 VDD VDD P L=0.18U W=5.8U
m15 XPA1 AP0-AIND0 VSS VSS N L=0.18U W=2.49U
m2 N15 AX0 VSS VSS N L=0.18U W=0.42U
m4 AP0-AIND1 VDD VDD VDD P L=0.18U W=1.3U
m5 N30 VDD VSS VSS N L=0.18U W=1.3U
m6 AP0-AIND1 N15 VDD VDD P L=0.18U W=1.3U
m7 AP0-AIND1 N15 N30 VSS N L=0.18U W=1.3U
m8 XPA0 AP0-AIND1 VDD VDD P L=0.18U W=5.8U
m9 XPA0 AP0-AIND1 VSS VSS N L=0.18U W=2.49U
.ENDS rf2p_512x64_4_50HXP12
****
.SUBCKT rf2p_512x64_4_50HXP24 AGTP AX0 AX1 CLK GTP GTPIO XPA0 XPA1 XPA2 XPA3
+  XPB0 XPB1 XPB2 XPB3 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50HXP24: 30 flat devices **
d3 VSS AX0 DN 0.3364P 2.32U
d30 VSS AX1 DN 0.3364P 2.32U
m1 N19 AX0 VDD VDD P L=0.18U W=0.85U
m10 AP0-AIND0 N21 VDD VDD P L=0.18U W=1.3U
m11 N37 N21 VSS VSS N L=0.18U W=1.3U
m12 AP0-AIND0 AX0 VDD VDD P L=0.18U W=1.3U
m13 AP0-AIND0 AX0 N37 VSS N L=0.18U W=1.3U
m14 XPA1 AP0-AIND0 VDD VDD P L=0.18U W=5.8U
m15 XPA1 AP0-AIND0 VSS VSS N L=0.18U W=2.49U
m16 AP1-AIND1 AX1 VDD VDD P L=0.18U W=1.3U
m17 N48 AX1 VSS VSS N L=0.18U W=1.3U
m18 AP1-AIND1 AX0 VDD VDD P L=0.18U W=1.3U
m19 AP1-AIND1 AX0 N48 VSS N L=0.18U W=1.3U
m2 N19 AX0 VSS VSS N L=0.18U W=0.42U
m20 XPA3 AP1-AIND1 VDD VDD P L=0.18U W=5.8U
m21 XPA3 AP1-AIND1 VSS VSS N L=0.18U W=2.49U
m22 AP1-AIND0 AX1 VDD VDD P L=0.18U W=1.3U
m23 N49 AX1 VSS VSS N L=0.18U W=1.3U
m24 AP1-AIND0 N19 VDD VDD P L=0.18U W=1.3U
m25 AP1-AIND0 N19 N49 VSS N L=0.18U W=1.3U
m26 XPA2 AP1-AIND0 VDD VDD P L=0.18U W=5.8U
m27 XPA2 AP1-AIND0 VSS VSS N L=0.18U W=2.49U
m28 N21 AX1 VDD VDD P L=0.18U W=0.85U
m29 N21 AX1 VSS VSS N L=0.18U W=0.42U
m4 AP0-AIND1 N21 VDD VDD P L=0.18U W=1.3U
m5 N36 N21 VSS VSS N L=0.18U W=1.3U
m6 AP0-AIND1 N19 VDD VDD P L=0.18U W=1.3U
m7 AP0-AIND1 N19 N36 VSS N L=0.18U W=1.3U
m8 XPA0 AP0-AIND1 VDD VDD P L=0.18U W=5.8U
m9 XPA0 AP0-AIND1 VSS VSS N L=0.18U W=2.49U
.ENDS rf2p_512x64_4_50HXP24
****
.SUBCKT rf2p_512x64_4_50HXP24R AGTP AX0 AX1 CLK GTP GTPIO_WEI STUBG2 STUBG3
+  XPA0 XPA1 XPA2 XPA3 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50HXP24R: 30 flat devices **
d3 VSS AX0 DN 0.3364P 2.32U
d30 VSS AX1 DN 0.3364P 2.32U
m1 N17 AX0 VDD VDD P L=0.18U W=0.85U
m10 AP_I0-AIND0 N19 VDD VDD P L=0.18U W=1.3U
m11 N35 N19 VSS VSS N L=0.18U W=1.3U
m12 AP_I0-AIND0 AX0 VDD VDD P L=0.18U W=1.3U
m13 AP_I0-AIND0 AX0 N35 VSS N L=0.18U W=1.3U
m14 XPA1 AP_I0-AIND0 VDD VDD P L=0.18U W=5.8U
m15 XPA1 AP_I0-AIND0 VSS VSS N L=0.18U W=2.49U
m16 AP1-AIND1 AX1 VDD VDD P L=0.18U W=1.3U
m17 N46 AX1 VSS VSS N L=0.18U W=1.3U
m18 AP1-AIND1 AX0 VDD VDD P L=0.18U W=1.3U
m19 AP1-AIND1 AX0 N46 VSS N L=0.18U W=1.3U
m2 N17 AX0 VSS VSS N L=0.18U W=0.42U
m20 XPA3 AP1-AIND1 VDD VDD P L=0.18U W=5.8U
m21 XPA3 AP1-AIND1 VSS VSS N L=0.18U W=2.49U
m22 AP1-AIND0 AX1 VDD VDD P L=0.18U W=1.3U
m23 N47 AX1 VSS VSS N L=0.18U W=1.3U
m24 AP1-AIND0 N17 VDD VDD P L=0.18U W=1.3U
m25 AP1-AIND0 N17 N47 VSS N L=0.18U W=1.3U
m26 XPA2 AP1-AIND0 VDD VDD P L=0.18U W=5.8U
m27 XPA2 AP1-AIND0 VSS VSS N L=0.18U W=2.49U
m28 N19 AX1 VDD VDD P L=0.18U W=0.85U
m29 N19 AX1 VSS VSS N L=0.18U W=0.42U
m4 AP_I0-AIND1 N19 VDD VDD P L=0.18U W=1.3U
m5 N34 N19 VSS VSS N L=0.18U W=1.3U
m6 AP_I0-AIND1 N17 VDD VDD P L=0.18U W=1.3U
m7 AP_I0-AIND1 N17 N34 VSS N L=0.18U W=1.3U
m8 XPA0 AP_I0-AIND1 VDD VDD P L=0.18U W=5.8U
m9 XPA0 AP_I0-AIND1 VSS VSS N L=0.18U W=2.49U
.ENDS rf2p_512x64_4_50HXP24R
****
.SUBCKT rf2p_512x64_4_50HXPS_WR AGTP AX0 AX0_0 AX0_1 AX0_2 AX1 AX1_0 AX1_1 CLK
+  GTP GTPIO_WEI STUBG2 STUBG3 XPA0 XPA0_0 XPA0_1 XPA0_2 XPA1 XPA1_0 XPA1_1
+  XPA1_2 XPA2 XPA2_0 XPA2_1 XPA3 XPA3_0 XPA3_1 XPB0 XPB0_0 XPB0_1 XPB1 XPB1_0
+  XPB1_1 XPB2 XPB2_0 XPB3 XPB3_0 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50HXPS_WR: 105 flat devices **
XI0_1 AGTP AX0 CLK GTP GTPIO_WEI XPA0 XPA1 XPB0 XPB1 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50HXP12
XI1_1 AGTP AX0_0 AX1 CLK GTP GTPIO_WEI XPA0_0 XPA1_0 XPA2 XPA3 XPB0_0 XPB1_0
+  XPB2 XPB3 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXP24
XI2_1 AGTP AX0_1 AX1_0 CLK GTP GTPIO_WEI XPA0_1 XPA1_1 XPA2_0 XPA3_0 XPB0_1
+  XPB1_1 XPB2_0 XPB3_0 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXP24
XI3_1 AGTP AX0_2 AX1_1 CLK GTP GTPIO_WEI STUBG2 STUBG3 XPA0_2 XPA1_2 XPA2_1
+  XPA3_1 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXP24R
.ENDS rf2p_512x64_4_50HXPS_WR
****
.SUBCKT rf2p_512x64_4_50HXPS_SA AGTP AX0 AX0_0 AX0_1 AX0_2 AX1 AX1_0 AX1_1 CLK
+  GTP GTPIO_WEI STUBG2 STUBG3 XPA0 XPA0_0 XPA0_1 XPA0_2 XPA1 XPA1_0 XPA1_1
+  XPA1_2 XPA2 XPA2_0 XPA2_1 XPA3 XPA3_0 XPA3_1 XPB0 XPB0_0 XPB0_1 XPB1 XPB1_0
+  XPB1_1 XPB2 XPB2_0 XPB3 XPB3_0 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50HXPS_SA: 105 flat devices **
XI0_1 AGTP AX0 CLK GTP GTPIO_WEI XPA0 XPA1 XPB0 XPB1 YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50HXP12
XI1_1 AGTP AX0_0 AX1 CLK GTP GTPIO_WEI XPA0_0 XPA1_0 XPA2 XPA3 XPB0_0 XPB1_0
+  XPB2 XPB3 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXP24
XI2_1 AGTP AX0_1 AX1_0 CLK GTP GTPIO_WEI XPA0_1 XPA1_1 XPA2_0 XPA3_0 XPB0_1
+  XPB1_1 XPB2_0 XPB3_0 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXP24
XI3_1 AGTP AX0_2 AX1_1 CLK GTP GTPIO_WEI STUBG2 STUBG3 XPA0_2 XPA1_2 XPA2_1
+  XPA3_1 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXP24R
.ENDS rf2p_512x64_4_50HXPS_SA
****
.SUBCKT rf2p_512x64_4_50CTRLWRR2 AGTP CEN CLK GTP GTPIO_WEI MBL STOV TMS YP0
+  YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CTRLWRR2: 54 flat devices **
d42 VSS CEN DN 0.3364P 2.32U
d43 VSS CLK DN 0.3364P 2.32U
d44 VSS TMS DN 0.3364P 2.32U
d45 VSS STOV DN 0.3364P 2.32U
m1 GTP GTPN VDD VDD P L=0.18U W=50U
m10 GTCLK GTPNMIR VDD VDD P L=0.18U W=0.42U
m11 N67 GTPNMIR N68 VSS N L=0.18U W=0.42U
m12 GTCLK CEL VDD VDD P L=0.18U W=0.42U
m13 GTCLK CEL N67 VSS N L=0.18U W=0.42U
m14 N70 MBLN VSS VSS N L=0.18U W=3U
m15 RST CKSTOV N70 VSS N L=0.18U W=3U
m16 RST MBLN VDD VDD P L=0.18U W=6.41U
m17 N69 MBLN VSS VSS N L=0.18U W=3U
m18 RST CKSTOV VDD VDD P L=0.18U W=6.41U
m19 RST CKSTOV N69 VSS N L=0.18U W=3U
m2 GTP GTPN VSS VSS N L=0.18U W=22U
m20 CKSTOV STOV VDD VDD P L=0.18U W=3.78U
m21 N71 STOV VSS VSS N L=0.18U W=3.54U
m22 CKSTOV CLK VDD VDD P L=0.18U W=3.78U
m23 CKSTOV CLK N71 VSS N L=0.18U W=3.54U
m24 MBLN MBL VDD VDD P L=0.18U W=5.29U
m25 MBLN MBL VSS VSS N L=0.18U W=1.77U
m26 CENMML CLKN N73 VDD P L=0.18U W=0.22U
m27 N73 CEL VDD VDD P L=0.18U W=0.22U
m28 CENMML CLK N72 VSS N L=0.18U W=0.22U
m29 N72 CEL VSS VSS N L=0.18U W=0.22U
m3 GTPN GTPKEEP VDD VDD P L=0.36U W=0.22U
m30 CEL CENMML VDD VDD P L=0.18U W=1U
m31 CEL CENMML VSS VSS N L=0.18U W=0.47U
m32 CLKN CLK VDD VDD P L=0.18U W=0.53U
m33 CLKN CLK VSS VSS N L=0.18U W=0.25U
m34 N51 CLKN VSS VSS N L=0.18U W=0.53U
m35 N53 CLK VDD VDD P L=0.18U W=1.1U
m36 CENMML N55 N56 VDD P L=0.18U W=1.1U
m37 CENMML N55 N51 VSS N L=0.18U W=0.53U
m38 N56 TMS N53 VDD P L=0.18U W=1.1U
m39 CENMML TMS N51 VSS N L=0.18U W=0.53U
m4 GTPN GTPKEEP VSS VSS N L=0.36U W=0.22U
m40 N55 CEN VDD VDD P L=0.18U W=0.45U
m41 N55 CEN VSS VSS N L=0.18U W=0.22U
m46 GTPN GTCLKN CLKINV VSS N L=0.18U W=10U
m47 GTCLKN GTCLK VDD VDD P L=0.18U W=1.22U
m48 GTCLKN GTCLK VSS VSS N L=0.18U W=0.62U
m49 GTPNMIR GTP VDD VDD P L=0.18U W=0.8U
m5 GTPKEEP GTPN VDD VDD P L=0.18U W=0.22U
m50 GTPNMIR GTP VSS VSS N L=0.18U W=0.42U
m51 CLKINV CLK VDD VDD P L=0.18U W=20U
m52 CLKINV CLK VSS VSS N L=0.18U W=10U
m53 AGTP GTPN VDD VDD P L=0.18U W=3.7U
m54 AGTP GTPN VSS VSS N L=0.18U W=1.24U
m6 GTPKEEP GTPN VSS VSS N L=0.18U W=0.22U
m7 GTPN RST VDD VDD P L=0.18U W=15.02U
m8 GTCLK CLKINV VDD VDD P L=0.18U W=0.42U
m9 N68 CLKINV VSS VSS N L=0.18U W=0.42U
.ENDS rf2p_512x64_4_50CTRLWRR2
****
.SUBCKT rf2p_512x64_4_50CCMBL BLA BLA_ BLB BLB_ WLA WLB VSS VDD
** rf2p_512x64_4_50CCMBL: 8 flat devices **
m1 BLB VSS CORED VSS N L=0.18U W=0.42U
m2 BLB_ VSS CORED_ VSS N L=0.18U W=0.42U
m3 BLA VSS CORED VSS N L=0.18U W=0.42U
m4 BLA_ VSS CORED_ VSS N L=0.18U W=0.42U
m5 CORED_ CORED VDD VDD P L=0.18U W=0.22U
m6 CORED_ CORED VSS VSS N L=0.18U W=1.49U
m7 CORED CORED_ VDD VDD P L=0.18U W=0.22U
m8 CORED CORED_ VSS VSS N L=0.18U W=1.49U
.ENDS rf2p_512x64_4_50CCMBL
****
.SUBCKT rf2p_512x64_4_50CCMBL2 BLA BLA_ BLB BLB_ WLA WLA_0 WLB WLB_0 VSS VDD
** rf2p_512x64_4_50CCMBL2: 16 flat devices **
XI0 BLA BLA_ BLB BLB_ WLA WLB VSS VDD rf2p_512x64_4_50CCMBL
XI1 BLA BLA_ BLB BLB_ WLA_0 WLB_0 VSS VDD rf2p_512x64_4_50CCMBL
.ENDS rf2p_512x64_4_50CCMBL2
****
.SUBCKT rf2p_512x64_4_50MBLBASE MBLA MBLA_ MBLB MBLB_ MWLA MWLAS MWLB MWLBS
+  VSS VDD
** rf2p_512x64_4_50MBLBASE: 16 flat devices **
m1 N13 VDD VSS VSS N L=0.18U W=1.49U
m10 N18 MWLB MBLB VSS N L=0.18U W=0.42U
m11 N17 VDD VSS VSS N L=0.18U W=1.49U
m12 N18 VDD VSS VSS N L=0.18U W=1.49U
m13 N19 VDD VSS VSS N L=0.18U W=1.49U
m14 N19 MWLA MBLA VSS N L=0.18U W=0.42U
m15 N20 VDD VSS VSS N L=0.18U W=1.49U
m16 N20 MWLB MBLB VSS N L=0.18U W=0.42U
m2 N13 MWLA MBLA VSS N L=0.18U W=0.42U
m3 N14 VDD VSS VSS N L=0.18U W=1.49U
m4 N14 MWLB MBLB VSS N L=0.18U W=0.42U
m5 N15 MWLA MBLA VSS N L=0.18U W=0.42U
m6 N16 MWLA MBLA VSS N L=0.18U W=0.42U
m7 N15 VDD VSS VSS N L=0.18U W=1.49U
m8 N16 VDD VSS VSS N L=0.18U W=1.49U
m9 N17 MWLB MBLB VSS N L=0.18U W=0.42U
.ENDS rf2p_512x64_4_50MBLBASE
****
.SUBCKT rf2p_512x64_4_50FLCWRRNB GTP MBL MBLA MBLA_ MBLB MBLB_ YP0 YP1 YP2 YP3
+  VSS VDD
** rf2p_512x64_4_50FLCWRRNB: 3 flat devices **
m1 MBLB GTP VDD VDD P L=0.18U W=2.8U
m2 MBLB_ GTP VDD VDD P L=0.18U W=2.8U
m3 MBLB GTP MBLB_ VDD P L=0.18U W=2.8U
.ENDS rf2p_512x64_4_50FLCWRRNB
****
.SUBCKT rf2p_512x64_4_50MODEL_COL BLA BLA_ BLB BLB_ GTP MWLA MWLAS MWLB MWLBS
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30
+  WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40
+  WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50
+  WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60
+  WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70
+  WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80
+  WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90
+  WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100
+  WLA_101 WLA_102 WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109
+  WLA_110 WLA_111 WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118
+  WLA_119 WLA_120 WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72
+  WLB_73 WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82
+  WLB_83 WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92
+  WLB_93 WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102
+  WLB_103 WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111
+  WLB_112 WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120
+  WLB_121 WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50MODEL_COL: 1043 flat devices **
XI0 GTP BLB BLA_ BLA BLB BLB_ YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50FLCWRRNB
XI1 BLA_ BLA BLB_ BLB WLA WLA_0 WLB WLB_0 VSS VDD rf2p_512x64_4_50CCMBL2
XI10 BLA_ BLA BLB_ BLB WLA_17 WLA_18 WLB_17 WLB_18 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI11 BLA_ BLA BLB_ BLB WLA_19 WLA_20 WLB_19 WLB_20 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI12 BLA_ BLA BLB_ BLB WLA_21 WLA_22 WLB_21 WLB_22 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI13 BLA_ BLA BLB_ BLB WLA_23 WLA_24 WLB_23 WLB_24 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI14 BLA_ BLA BLB_ BLB WLA_25 WLA_26 WLB_25 WLB_26 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI15 BLA_ BLA BLB_ BLB WLA_27 WLA_28 WLB_27 WLB_28 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI16 BLA_ BLA BLB_ BLB WLA_29 WLA_30 WLB_29 WLB_30 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI18 BLA BLA_ BLB BLB_ WLA_31 WLA_32 WLB_31 WLB_32 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI19 BLA BLA_ BLB BLB_ WLA_33 WLA_34 WLB_33 WLB_34 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI2 BLA_ BLA BLB_ BLB WLA_1 WLA_2 WLB_1 WLB_2 VSS VDD rf2p_512x64_4_50CCMBL2
XI20 BLA BLA_ BLB BLB_ WLA_35 WLA_36 WLB_35 WLB_36 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI21 BLA BLA_ BLB BLB_ WLA_37 WLA_38 WLB_37 WLB_38 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI22 BLA BLA_ BLB BLB_ WLA_39 WLA_40 WLB_39 WLB_40 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI23 BLA BLA_ BLB BLB_ WLA_41 WLA_42 WLB_41 WLB_42 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI24 BLA BLA_ BLB BLB_ WLA_43 WLA_44 WLB_43 WLB_44 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI25 BLA BLA_ BLB BLB_ WLA_45 WLA_46 WLB_45 WLB_46 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI26 BLA BLA_ BLB BLB_ WLA_47 WLA_48 WLB_47 WLB_48 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI27 BLA BLA_ BLB BLB_ WLA_49 WLA_50 WLB_49 WLB_50 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI28 BLA BLA_ BLB BLB_ WLA_51 WLA_52 WLB_51 WLB_52 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI29 BLA BLA_ BLB BLB_ WLA_53 WLA_54 WLB_53 WLB_54 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI3 BLA_ BLA BLB_ BLB WLA_3 WLA_4 WLB_3 WLB_4 VSS VDD rf2p_512x64_4_50CCMBL2
XI30 BLA BLA_ BLB BLB_ WLA_55 WLA_56 WLB_55 WLB_56 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI31 BLA BLA_ BLB BLB_ WLA_57 WLA_58 WLB_57 WLB_58 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI32 BLA BLA_ BLB BLB_ WLA_59 WLA_60 WLB_59 WLB_60 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI33 BLA BLA_ BLB BLB_ WLA_61 WLA_62 WLB_61 WLB_62 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI34 BLA BLA_ BLB BLB_ MWLA MWLAS MWLB MWLBS VSS VDD rf2p_512x64_4_50MBLBASE
XI35 BLA_ BLA BLB_ BLB WLA_63 WLA_64 WLB_63 WLB_64 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI36 BLA_ BLA BLB_ BLB WLA_65 WLA_66 WLB_65 WLB_66 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI37 BLA_ BLA BLB_ BLB WLA_67 WLA_68 WLB_67 WLB_68 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI38 BLA_ BLA BLB_ BLB WLA_69 WLA_70 WLB_69 WLB_70 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI39 BLA_ BLA BLB_ BLB WLA_71 WLA_72 WLB_71 WLB_72 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI4 BLA_ BLA BLB_ BLB WLA_5 WLA_6 WLB_5 WLB_6 VSS VDD rf2p_512x64_4_50CCMBL2
XI40 BLA_ BLA BLB_ BLB WLA_73 WLA_74 WLB_73 WLB_74 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI41 BLA_ BLA BLB_ BLB WLA_75 WLA_76 WLB_75 WLB_76 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI42 BLA_ BLA BLB_ BLB WLA_77 WLA_78 WLB_77 WLB_78 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI43 BLA_ BLA BLB_ BLB WLA_79 WLA_80 WLB_79 WLB_80 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI44 BLA_ BLA BLB_ BLB WLA_81 WLA_82 WLB_81 WLB_82 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI45 BLA_ BLA BLB_ BLB WLA_83 WLA_84 WLB_83 WLB_84 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI46 BLA_ BLA BLB_ BLB WLA_85 WLA_86 WLB_85 WLB_86 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI47 BLA_ BLA BLB_ BLB WLA_87 WLA_88 WLB_87 WLB_88 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI48 BLA_ BLA BLB_ BLB WLA_89 WLA_90 WLB_89 WLB_90 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI49 BLA_ BLA BLB_ BLB WLA_91 WLA_92 WLB_91 WLB_92 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI5 BLA_ BLA BLB_ BLB WLA_7 WLA_8 WLB_7 WLB_8 VSS VDD rf2p_512x64_4_50CCMBL2
XI51 BLA BLA_ BLB BLB_ WLA_93 WLA_94 WLB_93 WLB_94 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI52 BLA BLA_ BLB BLB_ WLA_95 WLA_96 WLB_95 WLB_96 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI53 BLA BLA_ BLB BLB_ WLA_97 WLA_98 WLB_97 WLB_98 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI54 BLA BLA_ BLB BLB_ WLA_99 WLA_100 WLB_99 WLB_100 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI55 BLA BLA_ BLB BLB_ WLA_101 WLA_102 WLB_101 WLB_102 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI56 BLA BLA_ BLB BLB_ WLA_103 WLA_104 WLB_103 WLB_104 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI57 BLA BLA_ BLB BLB_ WLA_105 WLA_106 WLB_105 WLB_106 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI58 BLA BLA_ BLB BLB_ WLA_107 WLA_108 WLB_107 WLB_108 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI59 BLA BLA_ BLB BLB_ WLA_109 WLA_110 WLB_109 WLB_110 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI6 BLA_ BLA BLB_ BLB WLA_9 WLA_10 WLB_9 WLB_10 VSS VDD rf2p_512x64_4_50CCMBL2
XI60 BLA BLA_ BLB BLB_ WLA_111 WLA_112 WLB_111 WLB_112 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI61 BLA BLA_ BLB BLB_ WLA_113 WLA_114 WLB_113 WLB_114 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI62 BLA BLA_ BLB BLB_ WLA_115 WLA_116 WLB_115 WLB_116 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI63 BLA BLA_ BLB BLB_ WLA_117 WLA_118 WLB_117 WLB_118 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI64 BLA BLA_ BLB BLB_ WLA_119 WLA_120 WLB_119 WLB_120 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI65 BLA BLA_ BLB BLB_ WLA_121 WLA_122 WLB_121 WLB_122 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI66 BLA BLA_ BLB BLB_ WLA_123 WLA_124 WLB_123 WLB_124 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI67 BLA BLA_ BLB BLB_ WLA_125 WLA_126 WLB_125 WLB_126 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI7 BLA_ BLA BLB_ BLB WLA_11 WLA_12 WLB_11 WLB_12 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI8 BLA_ BLA BLB_ BLB WLA_13 WLA_14 WLB_13 WLB_14 VSS VDD
+  rf2p_512x64_4_50CCMBL2
XI9 BLA_ BLA BLB_ BLB WLA_15 WLA_16 WLB_15 WLB_16 VSS VDD
+  rf2p_512x64_4_50CCMBL2
.ENDS rf2p_512x64_4_50MODEL_COL
****
.SUBCKT rf2p_512x64_4_50CTRLSAR2 AGTP CLK DELAY2 DELAY3 DELAY3OUT DELAY4
+  DELAY4OUT GTP GTPB GTPSA MBL MBLA MBLA_ MBLB MBLB_ STOV YP0 YP1 YP2 YP3 VSS
+  VDD
** rf2p_512x64_4_50CTRLSAR2: 52 flat devices **
d30 VSS STOV DN 0.3364P 2.32U
m1 N32 GTP VDD VDD P L=0.18U W=8.8U
m10 GTPSANINV MBL N39 VDD P L=0.18U W=7.68U
m11 GTPKEEPSA GTPSANINV VDD VDD P L=0.18U W=0.22U
m12 GTPKEEPSA GTPSANINV VSS VSS N L=0.18U W=0.22U
m13 CLKSTOV CLK VDD VDD P L=0.18U W=0.78U
m14 N77 CLK VSS VSS N L=0.18U W=2.58U
m15 CLKSTOV STOV VDD VDD P L=0.18U W=0.78U
m16 CLKSTOV STOV N77 VSS N L=0.18U W=2.58U
m17 N79 GTP VSS VSS N L=0.18U W=2.19U
m18 SASET CLKSTOV N79 VSS N L=0.18U W=2.19U
m19 SASET GTP VDD VDD P L=0.18U W=4.68U
m2 N32 GTP VSS VSS N L=0.18U W=4.4U
m20 N78 GTP VSS VSS N L=0.18U W=2.19U
m21 SASET CLKSTOV VDD VDD P L=0.18U W=4.68U
m22 SASET CLKSTOV N78 VSS N L=0.18U W=2.19U
m23 MBLA GTP VDD VDD P L=0.18U W=2.8U
m24 MBLA_ GTP VDD VDD P L=0.18U W=2.8U
m25 MBLA GTP MBLA_ VDD P L=0.18U W=2.8U
m26 GTPSANINV SDB N50 VSS N L=0.18U W=3.6U
m27 N50 N32 VSS VSS N L=0.18U W=3.6U
m28 GTPSANINV MBL N51 VDD P L=0.18U W=7.68U
m29 N51 SASET VDD VDD P L=0.18U W=7.68U
m3 GTPSA GTPSANINV VDD VDD P L=0.18U W=51.14U
m31 GTPSANINV SDB N53 VSS N L=0.18U W=3.6U
m32 N53 N32 VSS VSS N L=0.18U W=3.6U
m33 GTPSANINV SDB N54 VSS N L=0.18U W=3.6U
m34 N54 N32 VSS VSS N L=0.18U W=3.6U
m35 N55 SASET VDD VDD P L=0.18U W=7.68U
m36 GTPSANINV MBL N55 VDD P L=0.18U W=7.68U
m37 GTPSANINV MBL N57 VDD P L=0.18U W=7.68U
m38 N57 SASET VDD VDD P L=0.18U W=7.68U
m39 SDB N59 VDD VDD P L=0.18U W=8.8U
m4 GTPSA GTPSANINV VSS VSS N L=0.18U W=20.81U
m40 SDB N59 VSS VSS N L=0.18U W=4.4U
m41 N59 N62 VDD VDD P L=0.18U W=3U
m42 N59 N62 VSS VSS N L=0.18U W=1.6U
m43 N62 DELAY2 VDD VDD P L=0.18U W=1.2U
m44 N62 DELAY2 VSS VSS N L=0.18U W=0.6U
m45 N67 DELAY4 VDD VDD P L=0.36U W=0.42U
m46 N67 DELAY4 VSS VSS N L=0.36U W=0.42U
m47 DELAY3OUT N70 VDD VDD P L=0.36U W=0.42U
m48 DELAY3OUT N70 VSS VSS N L=0.36U W=0.42U
m49 N70 DELAY3 VDD VDD P L=0.36U W=0.42U
m5 GTPSANINV GTPKEEPSA VDD VDD P L=0.36U W=0.22U
m50 N70 DELAY3 VSS VSS N L=0.36U W=0.42U
m51 DELAY4OUT N67 VDD VDD P L=0.36U W=0.42U
m52 DELAY4OUT N67 VSS VSS N L=0.36U W=0.42U
m6 GTPSANINV GTPKEEPSA VSS VSS N L=0.36U W=0.22U
m7 N39 SASET VDD VDD P L=0.18U W=7.68U
m8 GTPSANINV SDB N41 VSS N L=0.18U W=3.6U
m9 N41 N32 VSS VSS N L=0.18U W=3.6U
.ENDS rf2p_512x64_4_50CTRLSAR2
****
.SUBCKT rf2p_512x64_4_50CTRLSAR2X AGTP CLK GTP GTPB GTPSA MBLA MBLA_ MBLB
+  MBLB_ STOV YP0 YP1 YP2 YP3 VSS VDD
** rf2p_512x64_4_50CTRLSAR2X: 52 flat devices **
XI0 AGTP CLK DELAY2 GTPSA DELAY2 VSS DELAY4OUT GTP GTPB GTPSA MBLA MBLA MBLA_
+  MBLB MBLB_ STOV YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50CTRLSAR2
.ENDS rf2p_512x64_4_50CTRLSAR2X
****
.SUBCKT rf2p_512x64_4_50BCOL_M_DN_3 D GTP GTPSA GTP_0 GTP_1 MWLAL MWLBL Q WEI
+  WLA WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30
+  WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40
+  WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50
+  WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60
+  WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70
+  WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80
+  WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90
+  WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100
+  WLA_101 WLA_102 WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109
+  WLA_110 WLA_111 WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118
+  WLA_119 WLA_120 WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31
+  WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41
+  WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51
+  WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61
+  WLB_62 WLB_63 WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71
+  WLB_72 WLB_73 WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81
+  WLB_82 WLB_83 WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91
+  WLB_92 WLB_93 WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101
+  WLB_102 WLB_103 WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110
+  WLB_111 WLB_112 WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119
+  WLB_120 WLB_121 WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0
+  YP2 YP2_0 YP3 YP3_0 VSS VDD
** rf2p_512x64_4_50BCOL_M_DN_3: 4346 flat devices **
XI0_0 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1
+  BLB_2 BLB__0 BLB__1 BLB__2 D GTP GTP_0 WEI YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50WR_MUX_DN_M
XI0_1 BLA_ BLA BLB_ BLB WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66
+  WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76
+  WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86
+  WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96
+  WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI0_2 BLA_ BLA BLA__0 BLA__1 BLA__2 BLA_0 BLA_1 BLA_2 BLB_ BLB BLB__0 BLB__1
+  BLB__2 BLB_0 BLB_1 BLB_2 GTP_1 GTPSA Q YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD
+  rf2p_512x64_4_50RD_MUX_DN
XI1_1 BLA__0 BLA_0 BLB__0 BLB_0 WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI2_1 BLA__1 BLA_1 BLB__1 BLB_1 WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65
+  WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75
+  WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85
+  WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95
+  WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36
+  WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46
+  WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56
+  WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66
+  WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76
+  WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86
+  WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96
+  WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_HCCMWG
XI3_1 BLA__2 BLA_2 BLB__2 BLB_2 MWLAL WLA0 MWLBL WLB0 WLA WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 VSS VDD rf2p_512x64_4_50CC_COL_FLMWG
.ENDS rf2p_512x64_4_50BCOL_M_DN_3
****
.SUBCKT rf2p_512x64_4_50WING_RIGHT_32 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8
+  D_9 D_10 D_11 D_12 D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 D_21 D_22 D_23
+  D_24 D_25 D_26 D_27 D_28 D_29 D_30 GTP GTPSA_ GTP_0 GTP_1 Q Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17 Q_18 Q_19
+  Q_20 Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28 Q_29 Q_30 WEI_ WLA WLA0 WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72
+  WLA_73 WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82
+  WLA_83 WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92
+  WLA_93 WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102
+  WLA_103 WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111
+  WLA_112 WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120
+  WLA_121 WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD
** rf2p_512x64_4_50WING_RIGHT_32: 139072 flat devices **
XI0 D GTP GTPSA_ GTP_0 GTP_1 Q WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI1 D_0 GTP GTPSA_ GTP_0 GTP_1 Q_0 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI10 D_9 GTP GTPSA_ GTP_0 GTP_1 Q_9 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI11 D_10 GTP GTPSA_ GTP_0 GTP_1 Q_10 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_DN
XI12 D_11 GTP GTPSA_ GTP_0 GTP_1 Q_11 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_UP
XI13 D_12 GTP GTPSA_ GTP_0 GTP_1 Q_12 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_DN
XI14 D_13 GTP GTPSA_ GTP_0 GTP_1 Q_13 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  WLB_64 WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73
+  WLB_74 WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83
+  WLB_84 WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93
+  WLB_94 WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103
+  WLB_104 WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112
+  WLB_113 WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121
+  WLB_122 WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3
+  YP3_0 VSS VDD rf2p_512x64_4_50BCOL_M_UP
XI15 D_14 GTP GTPSA_ GTP_0 GTP_1 WLA0 WLB0 Q_14 WEI_ WLA VSS WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64
+  WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74
+  WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84
+  WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94
+  WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104
+  WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113
+  WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122
+  WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS
+  VDD rf2p_512x64_4_50BCOL_M_DN_3
XI16 D_15 GTP GTPSA_ GTP_0 GTP_1 Q_15 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI17 D_16 GTP GTPSA_ GTP_0 GTP_1 Q_16 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI18 D_17 GTP GTPSA_ GTP_0 GTP_1 Q_17 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI19 D_18 GTP GTPSA_ GTP_0 GTP_1 Q_18 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI2 D_1 GTP GTPSA_ GTP_0 GTP_1 Q_1 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI20 D_19 GTP GTPSA_ GTP_0 GTP_1 Q_19 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI21 D_20 GTP GTPSA_ GTP_0 GTP_1 Q_20 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI22 D_21 GTP GTPSA_ GTP_0 GTP_1 Q_21 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI23 D_22 GTP GTPSA_ GTP_0 GTP_1 Q_22 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI24 D_23 GTP GTPSA_ GTP_0 GTP_1 Q_23 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI25 D_24 GTP GTPSA_ GTP_0 GTP_1 Q_24 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI26 D_25 GTP GTPSA_ GTP_0 GTP_1 Q_25 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI27 D_26 GTP GTPSA_ GTP_0 GTP_1 Q_26 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI28 D_27 GTP GTPSA_ GTP_0 GTP_1 Q_27 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI29 D_28 GTP GTPSA_ GTP_0 GTP_1 Q_28 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI3 D_2 GTP GTPSA_ GTP_0 GTP_1 Q_2 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI30 D_29 GTP GTPSA_ GTP_0 GTP_1 Q_29 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI31 D_30 GTP GTPSA_ GTP_0 GTP_1 Q_30 WEI_ WLA VSS VSS WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB VSS VSS WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI4 D_3 GTP GTPSA_ GTP_0 GTP_1 Q_3 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI5 D_4 GTP GTPSA_ GTP_0 GTP_1 Q_4 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI6 D_5 GTP GTPSA_ GTP_0 GTP_1 Q_5 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI7 D_6 GTP GTPSA_ GTP_0 GTP_1 Q_6 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
XI8 D_7 GTP GTPSA_ GTP_0 GTP_1 Q_7 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_UP
XI9 D_8 GTP GTPSA_ GTP_0 GTP_1 Q_8 WEI_ WLA WLA0 WLA0 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64
+  WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74
+  WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84
+  WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94
+  WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104
+  WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113
+  WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122
+  WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50BCOL_M_DN
.ENDS rf2p_512x64_4_50WING_RIGHT_32
****
.SUBCKT rf2p_512x64_4_50 AA[0] AA[1] AA[2] AA[3] AA[4] AA[5] AA[6] AA[7] AA[8]
+  AB[0] AB[1] AB[2] AB[3] AB[4] AB[5] AB[6] AB[7] AB[8] CENA CENB CLKA CLKB
+  DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11]
+  DB[12] DB[13] DB[14] DB[15] DB[16] DB[17] DB[18] DB[19] DB[20] DB[21]
+  DB[22] DB[23] DB[24] DB[25] DB[26] DB[27] DB[28] DB[29] DB[30] DB[31]
+  DB[32] DB[33] DB[34] DB[35] DB[36] DB[37] DB[38] DB[39] DB[40] DB[41]
+  DB[42] DB[43] DB[44] DB[45] DB[46] DB[47] DB[48] DB[49] DB[50] DB[51]
+  DB[52] DB[53] DB[54] DB[55] DB[56] DB[57] DB[58] DB[59] DB[60] DB[61]
+  DB[62] DB[63] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9]
+  QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] QA[16] QA[17] QA[18] QA[19]
+  QA[20] QA[21] QA[22] QA[23] QA[24] QA[25] QA[26] QA[27] QA[28] QA[29]
+  QA[30] QA[31] QA[32] QA[33] QA[34] QA[35] QA[36] QA[37] QA[38] QA[39]
+  QA[40] QA[41] QA[42] QA[43] QA[44] QA[45] QA[46] QA[47] QA[48] QA[49]
+  QA[50] QA[51] QA[52] QA[53] QA[54] QA[55] QA[56] QA[57] QA[58] QA[59]
+  QA[60] QA[61] QA[62] QA[63] VSS VDD
** rf2p_512x64_4_50: 286076 flat devices **
XI0_0 DB[31] DB[30] DB[29] DB[28] DB[27] DB[26] DB[25] DB[24] DB[23] DB[22]
+  DB[21] DB[20] DB[19] DB[18] DB[17] DB[16] DB[15] DB[14] DB[13] DB[12]
+  DB[11] DB[10] DB[9] DB[8] DB[7] DB[6] DB[5] DB[4] DB[3] DB[2] DB[1] DB[0]
+  GTP_0 GTPSA_ GTP_0 GTP_1 QA[31] QA[30] QA[29] QA[28] QA[27] QA[26] QA[25]
+  QA[24] QA[23] QA[22] QA[21] QA[20] QA[19] QA[18] QA[17] QA[16] QA[15]
+  QA[14] QA[13] QA[12] QA[11] QA[10] QA[9] QA[8] QA[7] QA[6] QA[5] QA[4]
+  QA[3] QA[2] QA[1] QA[0] VSS WLA WLA0 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLA_64 WLA_65 WLA_66
+  WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73 WLA_74 WLA_75 WLA_76
+  WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83 WLA_84 WLA_85 WLA_86
+  WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93 WLA_94 WLA_95 WLA_96
+  WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103 WLA_104 WLA_105
+  WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112 WLA_113 WLA_114
+  WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121 WLA_122 WLA_123
+  WLA_124 WLA_125 WLA_126 WLB WLB0 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6
+  WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17
+  WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27
+  WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37
+  WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47
+  WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57
+  WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65 WLB_66 WLB_67
+  WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75 WLB_76 WLB_77
+  WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85 WLB_86 WLB_87
+  WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95 WLB_96 WLB_97
+  WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105 WLB_106
+  WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114 WLB_115
+  WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123 WLB_124
+  WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS VDD
+  rf2p_512x64_4_50WING_LEFT_32
XI1_1 G2 G3 GTP_1 GTP_0 MBLA MBLB STUBG2 STUBG3 WLA WLA_1 WLA_3 WLA_5 WLA_7
+  WLA_9 WLA_11 WLA_13 WLA_15 WLA_17 WLA_19 WLA_21 WLA_23 WLA_25 WLA_27 WLA_29
+  WLA_31 WLA_33 WLA_35 WLA_37 WLA_39 WLA_41 WLA_43 WLA_45 WLA_47 WLA_49
+  WLA_51 WLA_53 WLA_55 WLA_57 WLA_59 WLA_61 WLA0 WLA_63 WLA_65 WLA_67 WLA_69
+  WLA_71 WLA_73 WLA_75 WLA_77 WLA_79 WLA_81 WLA_83 WLA_85 WLA_87 WLA_89
+  WLA_91 WLA_93 WLA_95 WLA_97 WLA_99 WLA_101 WLA_103 WLA_105 WLA_107 WLA_109
+  WLA_111 WLA_113 WLA_115 WLA_117 WLA_119 WLA_121 WLA_123 WLA_125 WLA_0 WLA_2
+  WLA_4 WLA_6 WLA_8 WLA_10 WLA_12 WLA_14 WLA_16 WLA_18 WLA_20 WLA_22 WLA_24
+  WLA_26 WLA_28 WLA_30 WLA_32 WLA_34 WLA_36 WLA_38 WLA_40 WLA_42 WLA_44
+  WLA_46 WLA_48 WLA_50 WLA_52 WLA_54 WLA_56 WLA_58 WLA_60 WLA_62 WLA_64
+  WLA_66 WLA_68 WLA_70 WLA_72 WLA_74 WLA_76 WLA_78 WLA_80 WLA_82 WLA_84
+  WLA_86 WLA_88 WLA_90 WLA_92 WLA_94 WLA_96 WLA_98 WLA_100 WLA_102 WLA_104
+  WLA_106 WLA_108 WLA_110 WLA_112 WLA_114 WLA_116 WLA_118 WLA_120 WLA_122
+  WLA_124 WLA_126 WLA0 WLA0 WLB WLB_1 WLB_3 WLB_5 WLB_7 WLB_9 WLB_11 WLB_13
+  WLB_15 WLB_17 WLB_19 WLB_21 WLB_23 WLB_25 WLB_27 WLB_29 WLB_31 WLB_33
+  WLB_35 WLB_37 WLB_39 WLB_41 WLB_43 WLB_45 WLB_47 WLB_49 WLB_51 WLB_53
+  WLB_55 WLB_57 WLB_59 WLB_61 WLB0 WLB_63 WLB_65 WLB_67 WLB_69 WLB_71 WLB_73
+  WLB_75 WLB_77 WLB_79 WLB_81 WLB_83 WLB_85 WLB_87 WLB_89 WLB_91 WLB_93
+  WLB_95 WLB_97 WLB_99 WLB_101 WLB_103 WLB_105 WLB_107 WLB_109 WLB_111
+  WLB_113 WLB_115 WLB_117 WLB_119 WLB_121 WLB_123 WLB_125 WLB_0 WLB_2 WLB_4
+  WLB_6 WLB_8 WLB_10 WLB_12 WLB_14 WLB_16 WLB_18 WLB_20 WLB_22 WLB_24 WLB_26
+  WLB_28 WLB_30 WLB_32 WLB_34 WLB_36 WLB_38 WLB_40 WLB_42 WLB_44 WLB_46
+  WLB_48 WLB_50 WLB_52 WLB_54 WLB_56 WLB_58 WLB_60 WLB_62 WLB_64 WLB_66
+  WLB_68 WLB_70 WLB_72 WLB_74 WLB_76 WLB_78 WLB_80 WLB_82 WLB_84 WLB_86
+  WLB_88 WLB_90 WLB_92 WLB_94 WLB_96 WLB_98 WLB_100 WLB_102 WLB_104 WLB_106
+  WLB_108 WLB_110 WLB_112 WLB_114 WLB_116 WLB_118 WLB_120 WLB_122 WLB_124
+  WLB_126 WLB0 WLB0 XP0 XP0_0 XP1 XP1_0 XP2 XP2_0 XP3 XP3_0 XPA0 XPA0_0
+  XPA0_1 XPA0_2 XPA0_3 XPA1 XPA1_0 XPA1_1 XPB0 XPB0_0 XPB0_1 XPB1 XPB1_0
+  XPB1_1 XPB1_2 XPB1_3 VSS VDD rf2p_512x64_4_50CTRL_MID
XI1_2 AGTP CENA CLKA GTP_1 GTPSA_ VSS YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD
+  rf2p_512x64_4_50CTRLSAL2
XI2_0 FAGTP AB[0] AB[1] VSS VDD VDD GTP_0 VSS INOUT0 INOUT1 INOUT2 XP0 XP1 XP2
+  XP3 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HYP24
XI3_2 AGTP AA[8] AA[6] AA[4] AA[2] AA[7] AA[5] AA[3] CLKA GTP_1 GTPSA_ STUBG2
+  STUBG3 XPB1_3 XPB1_1 XPB1 XP0 STUBG3 XPB0_1 XPB0 XP1 XPB1_2 XPB1_0 XP2
+  STUBG2 XPB0_0 XP3 XPA1_1 XPA1 G3 XPA0_3 XPA0_1 XPA0 XPA1_0 G2 XPA0_2 XPA0_0
+  YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD rf2p_512x64_4_50HXPS_SA
XI4_0 FAGTP AB[8] AB[6] AB[4] AB[2] AB[7] AB[5] AB[3] VSS GTP_0 VSS STUBG2_306
+  STUBG3_304 XPA0 XPA0_1 XPA0_3 XP0_0 G3 XPA1 XPA1_1 XP1_0 XPA0_0 XPA0_2
+  XP2_0 G2 XPA1_0 XP3_0 XPB0 XPB0_1 STUBG3 XPB1 XPB1_1 XPB1_3 XPB0_0 STUBG2
+  XPB1_0 XPB1_2 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50HXPS_WR
XI5_2 AGTP AA[0] AA[1] CLKA G2 G3 GTP_1 GTPSA_ INOUT0_312 INOUT1_310
+  INOUT2_308 XP0_0 XP1_0 XP2_0 XP3_0 YP0_0 YP1_0 YP2_0 YP3_0 VSS VDD
+  rf2p_512x64_4_50HYP24
XI6_0 FAGTP CENB CLKB GTP_0 VSS MBLB VSS VSS YP0 YP1 YP2 YP3 VSS VDD
+  rf2p_512x64_4_50CTRLWRR2
XI7_2 AGTP CLKA GTP_1 GTP_0 GTPSA_ MBLA BLA_ MBLB BLB_ VSS YP0_0 YP1_0 YP2_0
+  YP3_0 VSS VDD rf2p_512x64_4_50CTRLSAR2X
XI8_0 MBLA BLA_ MBLB BLB_ GTP_0 WLA0 WLA0 WLB0 WLB0 WLA WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64 WLB_65
+  WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74 WLB_75
+  WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84 WLB_85
+  WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94 WLB_95
+  WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104 WLB_105
+  WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113 WLB_114
+  WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122 WLB_123
+  WLB_124 WLB_125 WLB_126 YP0 YP1 YP2 YP3 VSS VDD rf2p_512x64_4_50MODEL_COL
XI9_0 DB[32] DB[33] DB[34] DB[35] DB[36] DB[37] DB[38] DB[39] DB[40] DB[41]
+  DB[42] DB[43] DB[44] DB[45] DB[46] DB[47] DB[48] DB[49] DB[50] DB[51]
+  DB[52] DB[53] DB[54] DB[55] DB[56] DB[57] DB[58] DB[59] DB[60] DB[61]
+  DB[62] DB[63] GTP_0 GTPSA_ GTP_0 GTP_1 QA[32] QA[33] QA[34] QA[35] QA[36]
+  QA[37] QA[38] QA[39] QA[40] QA[41] QA[42] QA[43] QA[44] QA[45] QA[46]
+  QA[47] QA[48] QA[49] QA[50] QA[51] QA[52] QA[53] QA[54] QA[55] QA[56]
+  QA[57] QA[58] QA[59] QA[60] QA[61] QA[62] QA[63] VSS WLA WLA0 WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63
+  WLA_64 WLA_65 WLA_66 WLA_67 WLA_68 WLA_69 WLA_70 WLA_71 WLA_72 WLA_73
+  WLA_74 WLA_75 WLA_76 WLA_77 WLA_78 WLA_79 WLA_80 WLA_81 WLA_82 WLA_83
+  WLA_84 WLA_85 WLA_86 WLA_87 WLA_88 WLA_89 WLA_90 WLA_91 WLA_92 WLA_93
+  WLA_94 WLA_95 WLA_96 WLA_97 WLA_98 WLA_99 WLA_100 WLA_101 WLA_102 WLA_103
+  WLA_104 WLA_105 WLA_106 WLA_107 WLA_108 WLA_109 WLA_110 WLA_111 WLA_112
+  WLA_113 WLA_114 WLA_115 WLA_116 WLA_117 WLA_118 WLA_119 WLA_120 WLA_121
+  WLA_122 WLA_123 WLA_124 WLA_125 WLA_126 WLB WLB0 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 WLB_64
+  WLB_65 WLB_66 WLB_67 WLB_68 WLB_69 WLB_70 WLB_71 WLB_72 WLB_73 WLB_74
+  WLB_75 WLB_76 WLB_77 WLB_78 WLB_79 WLB_80 WLB_81 WLB_82 WLB_83 WLB_84
+  WLB_85 WLB_86 WLB_87 WLB_88 WLB_89 WLB_90 WLB_91 WLB_92 WLB_93 WLB_94
+  WLB_95 WLB_96 WLB_97 WLB_98 WLB_99 WLB_100 WLB_101 WLB_102 WLB_103 WLB_104
+  WLB_105 WLB_106 WLB_107 WLB_108 WLB_109 WLB_110 WLB_111 WLB_112 WLB_113
+  WLB_114 WLB_115 WLB_116 WLB_117 WLB_118 WLB_119 WLB_120 WLB_121 WLB_122
+  WLB_123 WLB_124 WLB_125 WLB_126 YP0 YP0_0 YP1 YP1_0 YP2 YP2_0 YP3 YP3_0 VSS
+  VDD rf2p_512x64_4_50WING_RIGHT_32
.ENDS rf2p_512x64_4_50
